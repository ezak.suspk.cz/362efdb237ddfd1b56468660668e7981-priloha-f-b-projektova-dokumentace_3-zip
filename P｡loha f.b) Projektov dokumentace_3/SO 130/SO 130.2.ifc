Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 130.2.ifc
Time: 2025-02-27T11:25:11
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 130
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: situace; Příloha č.: 2; Část: D.1.9; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice

# IfcSite (2)
Name
UnknownName
Staveniště 1 | Properties - IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; DisplayName: Parcela; FingerPrint: 0; IsUsed: no; Name: Staveniště 1; StyleName: Parcela KN; CloneMeForDragging: yes; Bounds: ((0,0,0),(0,0,0)); Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon); General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes; ColorIndex: 256; Layer: 100-DIO omezeni 2; PlotStyleName: ByLayer; Geometry - Closed: no; IsPeriodic: no; IsPlanar: no; Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no; 3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes

# IfcBuiltElement (12)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; CloneMeForDragging: yes; IsNull: no; NumChanges: 2; RecordHistory: yes; ShowHistory: yes; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 130; Označení podobjektu: SO 130.2; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Dočasná komunikace B; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_M3 - Způsob stanovení objemu: řezová metoda
CZ_F1 - Fáze: dočasný stav
Name | Area | Bounds | ColorIndex | Layer | PlotStyleName | Staničení do | Skupina elementů | Staničení od | Označení elementu | Označení položky | Označení šablony vlastností | Reference | podrobná specifikace | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem
vozovka_chodník-obrusná vrstva | 4804.98 | ((-639315.651658581,-1063543.79946342,229.69765999104),(-638858.807772522,-1063477.6981255,230.22957103367)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | 0.47032 | vozovka/chodník | 0.00658 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ACO 11 | ČSN EN 13 108-1 | P2 | 128;128;128 | 95.2484 | CZ_M6 - Tloušťka: 0.04
vozovka_chodník-podkladní asfaltová vrstva | 4950.48 | ((-639315.651658581,-1063543.79946342,229.625523915091),(-638858.779369705,-1063477.61716719,230.18957103367)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | 0.47032 | vozovka/chodník | 0.00658 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ACP 16+ | ČSN EN 13 108-1 | P2 | 128;128;128 | 170.698 | CZ_M6 - Tloušťka: 0.07
vozovka_chodník-horní podkladní vrstva | 5527.86 | ((-639315.651658581,-1063543.79946342,229.465929759246),(-638858.651798837,-1063477.25351684,230.11957103367)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | 0.47032 | vozovka/chodník | 0.00658 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 396.914 | CZ_M6 - Tloušťka: 0.15
vozovka_chodník-spodní podkladní vrstva | 6060.26 | ((-639315.651658581,-1063543.79946337,229.230522378984),(-638858.5329816,-1063476.92262721,229.96957103367)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | 0.47032 | vozovka/chodník | 0.00658 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 598.812 | CZ_M6 - Tloušťka: 0.2
vozovka_chodník-zpevnění krajnic | 838.995 | ((-639315.128184283,-1063543.39397049,229.230522378984),(-638858.5329816,-1063476.92259082,230.261334135344)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | 0.47032 | vozovka/chodník | 0.00658 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 19.5091
vozovka_chodník-zpevnění krajnic | 307.258 | ((-639315.160388192,-1063543.08138648,229.631885075035),(-638858.731400501,-1063477.48045033,230.137441965918)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | 0.47032 | vozovka/chodník | 0.00658 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 9.0193
vozovka_chodník-zpevnění krajnic | 480.332 | ((-639283.757542818,-1063538.08906557,229.290176574981),(-638883.630219824,-1063490.36264686,230.228646257312)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | 0.43685 | vozovka/chodník | 0.03151 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 10.5742
vozovka_chodník-zpevnění krajnic | 179.743 | ((-639283.745113061,-1063537.57948736,229.682515874004),(-638883.388038429,-1063490.26124648,230.147372621074)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | 0.43687 | vozovka/chodník | 0.03128 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 5.24924
zemní práce-násyp | 42.7588 | ((-638888.808087588,-1063538.31652219,229.255799584185),(-638867.0363145,-1063534.03378648,229.392434546737)) | 3 | zemní práce-násyp | Barva_3 | 0.03759 | zemní práce | 0.01642 | násyp | 17110 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | zemina | ČSN 73 6133 | P100 | 0;255;0 | 0.468968
zemní práce-násyp | 181.125 | ((-638886.451829294,-1063543.60996522,229.04),(-638856.722778741,-1063531.28124349,229.400591937037)) | 3 | zemní práce-násyp | Barva_3 | 0.03552 | zemní práce | 0.00364 | násyp | 17110 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | zemina | ČSN 73 6133 | P100 | 0;255;0 | 8.10087
zemní práce-násyp | 4027.69 | ((-639319.463673734,-1063534.96010721,228.609997287233),(-638882.229861629,-1063476.67057429,229.77)) | 3 | zemní práce-násyp | Barva_3 | 0.47487 | zemní práce | 0.03309 | násyp | 17110 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | zemina | ČSN 73 6133 | P100 | 0;255;0 | 576.542
zemní práce-výkop_odkop | 708.642 | ((-639308.88240392,-1063526.42944996,229.315334075674),(-638896.813163297,-1063479.45370086,229.87)) | 36 | zemní práce-výkop_odkop | Barva_36 | 0.46358 | zemní práce | 0.04773 | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | P100 | 125;75;0 | 19.4788 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni

# IfcGeographicElement (3)
In: UnknownName
PredefinedType: TERRAIN
Properties - AutoRebuild: yes; HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: yes; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 130; Označení podobjektu: SO 130.2; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Dočasná komunikace B; Klasifikační systém: OTSKP; Označení šablony vlastností: I1+S1+E1+Z1+M2+F1
CZ_S1 - Reference: D.1.9.2
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu
CZ_F1 - Fáze: dočasný stav
Name | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Materiál | specifikace | podrobná specifikace | Textura / barva | Skupina přesnosti | Plocha
vozovka_chodník-infiltrační postřik-1 | -8744071 | vozovka_chodník-infiltrační postřik-1 | postřiky | ((-639430.504157194,-1063651.3994462,229.624273915091),(-638753.481695161,-1063373.45770284,230.12)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 0.00709 | 0.47032 | infiltrační postřik | vozovka/chodník | 572123 | infilitrační postřik | ČSN 73 6129 | kat. em. 1,0 kg/m2 | 0;255;255 | P2 | 2484.76
vozovka_chodník-spojovací postřik-1 | 2033246410 | vozovka_chodník-spojovací postřik-1 | postřiky | ((-639430.464925823,-1063651.31618599,229.69640999104),(-638753.500884995,-1063373.53360681,230.19)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 0.00537 | 0.46939 | spojovací postřik | vozovka/chodník | 572213 | spojovací postřik | ČSN 73 6129 | kat. em. 0,25 kg/m2 | 0;255;255 | P2 | 2422.01
zemní práce-pláň-1 | 1536191581 | zemní práce-pláň-1 | plan | ((-639430.432668919,-1063651.24772759,229.255799584185),(-638753.516663304,-1063373.59601674,229.77)) | 96 | zemní práce-pláň | Barva_96 | 0.00543 | 0.46665 | pláň | zemní práce | 18110 | nerelevantni | nerelevantni | nerelevantni | 0;128;0 | P10 | 2370.39
