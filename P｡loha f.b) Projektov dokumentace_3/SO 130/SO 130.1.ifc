Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 130.1.ifc
Time: 2025-03-05T13:15:32
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 130
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Zakázka: přeložka silnice II/322 Černá za Bory - Dašice; Stupeň PD: PDPS; Název výkresu: situace; Příloha č.: 2; Část: D.1.9; Datum PD: 10.2024; Místo: Pardubický kraj/ Pardubice - Dašice

# IfcSite (2)
Name
UnknownName
Staveniště 1 | Properties - IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsUsed: no; DisplayName: Parcela; FingerPrint: 0; Name: Staveniště 1; StyleName: Parcela KN; CloneMeForDragging: yes; Bounds: ((0,0,0),(0,0,0)); Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon); General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes; ColorIndex: 256; Layer: 100-DIO omezeni 2; PlotStyleName: ByLayer; Geometry - Closed: no; IsPeriodic: no; IsPlanar: no; Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no; 3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes

# IfcBuiltElement (14)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; CloneMeForDragging: yes; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: dočasný stav
CZ_I1 - Označení stavebního objektu: SO 130; Označení podobjektu: SO 130.1; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Dočasná komunikace A; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_M3 - Způsob stanovení objemu: řezová metoda
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Tloušťka | Skupina elementů | Staničení od | Staničení do | Označení elementu | Označení položky | Označení šablony vlastností | Reference | podrobná specifikace | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem
vozovka_chodník-podkladní asfaltová vrstva | 2376.04 | 2 | yes | ((-642878.623868699,-1062769.21943471,232.214341606748),(-642706.857876217,-1062722.00112275,233.180758202067)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | 0.07 | vozovka/chodník | 0.00571 | 0.19853 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ACP 16+ | ČSN EN 13 108-1 | P2 | 128;128;128 | 82.0866
vozovka_chodník-horní podkladní vrstva | 2620.93 | 2 | yes | ((-642878.780146779,-1062769.60320003,232.054748212595),(-642706.805928843,-1062722.00112275,233.110758202067)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | 0.15 | vozovka/chodník | 0.00571 | 0.19853 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 189.119
vozovka_chodník-obrusná vrstva | 2315.02 | 2 | yes | ((-642878.589074408,-1062769.13399188,232.286477513112),(-642706.86944196,-1062722.00112275,233.220758202067)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | 0.04 | vozovka/chodník | 0.00571 | 0.19853 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ACO 11 | ČSN EN 13 108-1 | P2 | 128;128;128 | 45.942
vozovka_chodník-spodní podkladní vrstva | 2862.84 | 2 | yes | ((-642878.920828558,-1062770.03213934,231.823220981607),(-642706.75891871,-1062722.00112275,232.960758202067)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | 0.2 | vozovka/chodník | 0.00571 | 0.19853 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 287.088
vozovka_chodník-zpevnění krajnic | 220.581 | 2 | yes | ((-642835.471194457,-1062760.51311062,231.944607003575),(-642736.155761809,-1062733.81228219,233.128236625291)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 |  | vozovka/chodník | 0.03431 | 0.15423 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 7.65839
vozovka_chodník-zpevnění krajnic | 75.9256 | 2 | yes | ((-642835.511954992,-1062760.61375911,232.346109243114),(-642736.082094413,-1062734.34728136,233.064607209231)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 |  | vozovka/chodník | 0.0343 | 0.15422 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 2.22897
vozovka_chodník-zpevnění krajnic | 336.161 | 2 | yes | ((-642878.926258856,-1062769.9455015,231.823220748234),(-642706.757955349,-1062722.09307347,233.127008202074)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 |  | vozovka/chodník | 0.00572 | 0.19853 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 8.70316
vozovka_chodník-zpevnění krajnic | 129.445 | 2 | yes | ((-642878.68263239,-1062769.36373816,232.220703053101),(-642706.838342963,-1062722.00112275,233.133258202074)) | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 |  | vozovka/chodník | 0.00571 | 0.19853 | zpevnění krajnic | 56930 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | ŠD | nerelevantni | P2 | 128;128;128 | 3.80188
zemní práce-násyp | 2035.13 | 2 | yes | ((-642865.474459122,-1062769.11373876,231.18),(-642710.106318478,-1062728.03141595,232.750146729538)) | 3 | zemní práce-násyp | Barva_3 |  | zemní práce | 0.00901 | 0.18404 | násyp | 17110 | I1+S1+E1+Z1+M3+F1 | D.1.9.2 | nerelevantni | zemina | ČSN 73 6133 | P100 | 0;255;0 | 369.658
zemní práce-výkop_odkop | 373.261 | 2 | yes | ((-642878.432489457,-1062753.15540977,231.848322868884),(-642706.872183466,-1062722.07108946,232.831)) | 36 | zemní práce-výkop_odkop | Barva_36 |  | zemní práce | 0.00571 | 0.19836 | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | P100 | 125;75;0 | 16.9706 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-spodní podkladní vrstva | 164.108 | 1 | no | ((-643001.510370616,-1062651.30262203,231.740001509413),(-642984.717713399,-1062642.44868041,232.140001509413)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | 0.2 | vozovka/chodník | 0 | 0.015 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 15.5509
vozovka_chodník-horní podkladní vrstva | 161.969 | 1 | no | ((-643001.510393886,-1062651.30267577,231.940001509413),(-642984.717736669,-1062642.44873415,232.290001509413)) | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | 0.15 | vozovka/chodník | 0 | 0.015 | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 11.6632
vozovka_chodník-podkladní asfaltová vrstva | 158.548 | 1 | no | ((-643001.510271515,-1062651.30266494,232.09),(-642984.717614298,-1062642.44872333,232.36)) | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | 0.07 | vozovka/chodník | 0 | 0.015 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ACP 16+ | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.44283
vozovka_chodník-obrusná vrstva | 157.265 | 1 | no | ((-643001.510271515,-1062651.30266494,232.16),(-642984.717614298,-1062642.44872333,232.4)) | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | 0.04 | vozovka/chodník | 0 | 0.015 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | D.1.9.2 | nerelevantni | ACO 11 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.11019

# IfcGeographicElement (6)
In: UnknownName
PredefinedType: TERRAIN
Properties - HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 130; Označení podobjektu: SO 130.1; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Dočasná komunikace A; Klasifikační systém: OTSKP; Označení šablony vlastností: I1+S1+E1+Z1+M2+F1
CZ_S1 - Reference: D.1.9.2
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu
CZ_F1 - Fáze: dočasný stav
Name | AutoRebuild = IsUsed | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Materiál | specifikace | podrobná specifikace | Textura / barva | Skupina přesnosti | Plocha
vozovka_chodník-infiltrační postřik-1 | yes | -1361488474 | vozovka_chodník-infiltrační postřik-1 | postřiky | ((-642991.269519476,-1062869.26943459,232.20673735293),(-642601.223141953,-1062609.57564041,233.110758202067)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 0.00955 | 0.195 | infiltrační postřik | vozovka/chodník | 572123 | infilitrační postřik | ČSN 73 6129 | kat. em. 1,0 kg/m2 | 0;255;255 | P2 | 1201.13
vozovka_chodník-spojovací postřik-1 | yes | 622049726 | vozovka_chodník-spojovací postřik-1 | postřiky | ((-642991.233069489,-1062869.18399176,232.278873428879),(-642601.23500233,-1062609.65291855,233.180758202067)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 0.00954 | 0.195 | spojovací postřik | vozovka/chodník | 572213 | spojovací postřik | ČSN 73 6129 | kat. em. 0,25 kg/m2 | 0;255;255 | P2 | 1178.08
zemní práce-pláň-1 | yes | 1520944208 | zemní práce-pláň-1 | plan | ((-642991.203099499,-1062869.11373876,231.843129757994),(-642601.244754196,-1062609.71645836,232.760758202067)) | 96 | zemní práce-pláň | Barva_96 | 0.00942 | 0.195 | pláň | zemní práce | 18110 | nerelevantni | nerelevantni | nerelevantni | 0;128;0 | P10 | 1153.43
vozovka_chodník-infiltrační postřik-2 | no | -1227533076 | vozovka_chodník-infiltrační postřik-2 | postřiky | ((-643101.510271515,-1062751.30266494,232.09),(-642884.717614298,-1062542.44872333,232.29)) | 4 | vozovka_chodník-infiltrační postřik | Barva_4 | 0 | 0.015 | infiltrační postřik | vozovka/chodník | 572123 | infilitrační postřik | ČSN 73 6129 | kat. em. 1,0 kg/m2 | 0;255;255 | P2 | 77.7773 | Description: Popis; Properties - Description: Popis
vozovka_chodník-spojovací postřik-2 | no | -628210992 | vozovka_chodník-spojovací postřik-2 | postřiky | ((-643101.510271515,-1062751.30266494,232.16),(-642884.717614298,-1062542.44872333,232.36)) | 4 | vozovka_chodník-spojovací postřik | Barva_4 | 0 | 0.015 | spojovací postřik | vozovka/chodník | 572213 | spojovací postřik | ČSN 73 6129 | kat. em. 0,25 kg/m2 | 0;255;255 | P2 | 77.7773 | Description: Popis; Properties - Description: Popis
zemní práce-pláň-2 | no | 1135086168 | zemní práce-pláň-2 | plan | ((-643101.510271515,-1062751.30266494,231.74),(-642884.717614298,-1062542.44872333,231.94)) | 96 | zemní práce-pláň | Barva_96 | 0 | 0.015 | pláň | zemní práce | 18110 | nerelevantni | nerelevantni | nerelevantni | 0;128;0 | P10 | 77.7773 | Description: Popis; Properties - Description: Popis
