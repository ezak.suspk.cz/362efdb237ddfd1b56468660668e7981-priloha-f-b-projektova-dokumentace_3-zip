Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 403.ifc
Time: 2025-03-17T11:37:55
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 403
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (5)
In: UnknownName
Properties - IsNull: no; RecordHistory: yes; ShowHistory: yes; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 403; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Rozvody NN; Staničení od: 336; Staničení do: 338; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | Bounds | ColorIndex | Layer | PlotStyleName | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Typ stavebního výrobku | Stavební výrobek | Specifikace | Podrobná specifikace = Výrobce = Kategorie stavebního výrobku | Reference | Textura / barva | Skupina přesnosti | Počet | Způsob stanovení počtu
Portály-vybavení elektro | 4.76 | 7 | ((-643198.376389435,-1062579.28012542,231.7),(-643197.344471029,-1062578.57971292,233.3)) | 40 | Portály-vybavení elektro | Barva_40 | Vybavení elektro | Portály | 743F22 | I1+S2+E1+Z1+M4+F1 | pilíř | elektroměrový rozvaděč | ER112/NKP7P-C | nerelevantni | D.4.3.2 | 255;165;0 | P1 | 1 | odečet z modelu
Portály-vybavení elektro | 4 | 6 | ((-643197.472067868,-1062579.62564149,231.7),(-643196.620763672,-1062579.01112722,233.3)) | 40 | Portály-vybavení elektro | Barva_40 | Vybavení elektro | Portály | 743D11 | I1+S2+E1+Z1+M4+F1 | pilíř | pojistková skříň | SS200/NKE1P-C kompaktní pilíř | nerelevantni | D.4.3.2 | 255;165;0 | P1 | 1 | odečet z modelu
Portály-vybavení elektro | 4 | 4 | ((-643199.097592596,-1062578.85254966,231.7),(-643198.246288399,-1062578.2380354,233.3)) | 40 | Portály-vybavení elektro | Barva_40 | Vybavení elektro | Portály | 743D11 | I1+S2+E1+Z1+M4+F1 | pilíř | pojistková skříň | SS100/NKE1P-C kompaktní pilíř | nerelevantni | D.4.3.2 | 255;165;0 | P1 | 1 | odečet z modelu
zemní práce-zásyp rýhy | 3.6 | 6 | ((-643198.296006554,-1062579.48083692,231.3),(-643197.296006554,-1062578.48083692,231.7)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 |  |  |  |  |  | 0;128;0 | P100 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni; CZ_M3 - Objem: 0.4; Způsob stanovení objemu: objemová metoda
zemní práce-výkop rýhy | 4 | 5 | ((-643198.296006554,-1062579.48083692,231.2),(-643197.296006554,-1062578.48083692,231.7)) | 36 | zemní práce-výkop rýhy | Barva_36 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 |  |  |  |  |  | 125;75;0 | P100 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni; CZ_M3 - Objem: 0.5; Způsob stanovení objemu: objemová metoda
