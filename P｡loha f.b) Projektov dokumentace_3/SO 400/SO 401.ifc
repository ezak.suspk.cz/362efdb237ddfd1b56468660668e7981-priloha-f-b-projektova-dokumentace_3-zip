Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 2

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 401.ifc
Time: 2025-03-14T14:19:13
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 401
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcAnnotation: StringLine (29)
In: UnknownName
PredefinedType: USERDEFINED
Properties - CorridorFeaturelineRegionName: All; CreateFeatureLineDynamicLink: yes; FeatureLineEndCriteriaBeadStation: 0; FeatureLineStartCriteriaBeadStation: 0; CurvesCount: 0; ElevationPointsCount: 0; StyleName: Modrá __________; DisplayName: Automatická návrhová linie koridoru; FingerPrint: 0; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: no; ShowToolTip: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Ikona)
General - ColorIndex: 6; Layer: kabelové vedení-kabel; Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: Barva_6; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 401; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Veřejné osvětlení; Označení elementu: kabel; Skupina elementů: kabelové vedení; Klasifikační systém: OTSKP; Označení položky: 742H12; Označení šablony vlastností: I1+S2+E1+Z1+M1+F1
CZ_S2 - Typ stavebního výrobku: kabel; Stavební výrobek: CYKY-J 4x16; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_Z1 - Textura / barva: 255;0;255; Skupina přesnosti: P10
CZ_M1 - Způsob stanovení délky: Délka 3D křivky
CZ_F1 - Fáze: trvalý stav
Name | CorridorFeaturelineCode | CorridorFeaturelineSide | CorridorName | Length2D | Length3D = Délka | MaxElevation | MaxGrade | MinElevation | MinGrade | PIPointsCount = PointsCount | Name | IsModified = IsModifiedGraphics | Bounds | Staničení od | Staničení do
úsek 1-Kabel1 | Kabel1 | Střed | úsek 1 | 191.6 | 191.708 | 232.068 | 0.408245 | 231.45 | 0.000427277 | 66 | úsek 1-Kabel1 | yes | ((-642928.058896202,-1062727.33986991,231.450211737076),(-642799.388007561,-1062675.63041857,232.067667946286)) | 623.66 | 713.69
úsek 1-Kabel1 (5) | Kabel1 | Střed | úsek 1 | 26.1884 | 26.3378 | 232.132 | 0.737779 | 231.575 | 0.012014 | 13 | úsek 1-Kabel1 (5) | no | ((-642856.314846671,-1062752.71697111,231.575111046846),(-642847.244168775,-1062736.09537367,232.131700152584)) | 712.87 | 725.31
úsek 1-Kabel1 (6) | Kabel1 | Levá | úsek 1 | 19.3543 | 19.3544 | 231.559 | 0.00282428 | 231.505 | 0.00276061 | 6 | úsek 1-Kabel1 (6) | no | ((-642856.15225884,-1062736.13565406,231.505111046846),(-642848.356280998,-1062718.42094916,231.558754285614)) | 713.79 | 712.96
úsek 1-Kabel1 (7) | Kabel1 | Střed | úsek 1 | 106.714 | 106.723 | 232.425 | 0.0200881 | 231.691 | 0.00119696 | 26 | úsek 1-Kabel1 (7) | yes | ((-642946.599314359,-1062718.29844981,231.691213587205),(-642847.857748395,-1062677.84297242,232.42542304413)) | 607.36 | 714.22
úsek 1-Kabel1 (8) | Kabel1 | Levá | úsek 1 | 13 | 13.0018 | 231.753 | 0.0165242 | 231.538 | 0.0165242 | 4 | úsek 1-Kabel1 (8) | no | ((-642799.82836537,-1062720.08993617,231.537970612706),(-642795.526554839,-1062707.8223192,231.752785640429)) | 763.38 | 773.03
úsek 1-Kabel1 (9) | Kabel1 | Levá | úsek 1 | 8 | 8.00229 | 230.739 | 0.0239108 | 230.548 | 0.0239108 | 3 | úsek 1-Kabel1 (9) | no | ((-642684.121347692,-1062713.324381,230.547912101442),(-642676.196882061,-1062712.22763834,230.739198145425)) | 844.82 | 850.66
úsek 1-Kabel1 (10) | Kabel1 | Střed | úsek 1 | 123.2 | 123.584 | 232.243 | 0.561272 | 230.618 | 0.000956817 | 49 | úsek 1-Kabel1 (10) | yes | ((-642795.432188555,-1062728.58014884,230.617912101442),(-642684.107638408,-1062706.68546518,232.243272238583)) | 773.13 | 844.9
úsek 1-Kabel1 (11) | Kabel1 | Střed | úsek 1 | 59.7625 | 59.8476 | 231.201 | 0.423911 | 230.238 | 0.01 | 22 | úsek 1-Kabel1 (11) | no | ((-642676.183172777,-1062716.5939416,230.237586380052),(-642620.057724589,-1062708.88294908,231.200795199216)) | 850.74 | 897.72
úsek 1-Kabel2 | Kabel2 | Pravá | úsek 1 | 2.60702 | 2.60865 | 232.068 | 0.0546593 | 232.018 | 0.0164009 | 4 | úsek 1-Kabel2 | no | ((-642800.000248107,-1062722.88343696,232.01849359712),(-642799.427589113,-1062720.35780813,232.067667946286)) | 763.25 | 764.27
úsek 1-Kabel2 (12) | Kabel2 | Pravá | úsek 1 | 28.9441 | 29.0193 | 232.032 | 0.385886 | 231.629 | 0.00387618 | 14 | úsek 1-Kabel2 (12) | yes | ((-642848.466003701,-1062725.50455164,231.62866694901),(-642820.590232844,-1062718.25823644,232.031776772189)) | 743.22 | 713.65
úsek 1-Kabel2 (13) | Kabel2 | Pravá | úsek 1 | 26.3822 | 26.5194 | 232.132 | 0.636016 | 231.575 | 0.0119613 | 13 | úsek 1-Kabel2 (13) | no | ((-642856.367115119,-1062752.76630025,231.575111046846),(-642847.19517898,-1062736.07926152,232.131700152584)) | 712.83 | 725.34
úsek 1-Kabel2 (14) | Kabel2 | Levá | úsek 1 | 19.3543 | 19.3544 | 231.599 | 0.00282428 | 231.545 | 0.00276061 | 6 | úsek 1-Kabel2 (14) | no | ((-642856.15225884,-1062736.13565406,231.545111046846),(-642848.356280998,-1062718.42094916,231.598754285614)) | 713.79 | 712.96
úsek 1-Kabel2 (15) | Kabel2 | Pravá | úsek 1 | 20.6079 | 20.6877 | 232.163 | 0.384627 | 231.275 | 0.011928 | 11 | úsek 1-Kabel2 (15) | no | ((-642767.18283666,-1062728.62095112,231.274753000953),(-642749.989931166,-1062718.0083484,232.163439887227)) | -1 | 796.14
úsek 2-Kabel1 | Kabel1 | Střed | úsek 2 | 4.2 | 4.32192 | 232.069 | 0.420661 | 231.64 | 0.0206607 | 6 | úsek 2-Kabel1 | no | ((-642846.825910624,-1062751.42231124,231.639634215056),(-642843.482674124,-1062750.40901824,232.069004242582)) | 725.69 | 728.86
úsek 2-Kabel1 (16) | Kabel1 | Střed | úsek 2 | 91.9065 | 92.1724 | 232.104 | 0.427972 | 230.153 | 0.00432572 | 30 | úsek 2-Kabel1 (16) | no | ((-642836.238230427,-1062784.97444624,230.153164227891),(-642757.191415056,-1062744.83102227,232.104478220498)) | 734.72 | 836.88
úsek 2-Kabel1 (17) | Kabel1 | Levá | úsek 2 | 7.5 | 7.50012 | 231.612 | 0.00558858 | 231.57 | 0.00558858 | 4 | úsek 2-Kabel1 (17) | no | ((-642843.508556028,-1062751.29108618,231.569634215056),(-642836.264112331,-1062749.34994334,231.611548582227)) | 728.81 | 734.67
úsek 2-Kabel1 (18) | Kabel1 | Střed | úsek 2 | 0.8 | 0.896986 | 230.475 | 0.589147 | 230.122 | 0.0775194 | 3 | úsek 2-Kabel1 (18) | no | ((-642761.042154495,-1062782.59289091,230.121521359308),(-642760.616975675,-1062781.91523099,230.475009746892)) | 832.5 | 832.37
úsek 2-Kabel1 (19) | Kabel1 | Střed | úsek 2 | 29.6 | 29.8109 | 232.435 | 0.477519 | 231.379 | 0.00167824 | 23 | úsek 2-Kabel1 (19) | no | ((-642755.257370057,-1062761.41601831,231.37870884223),(-642747.396112483,-1062740.10232913,232.435063024408)) | 828.25 | 813.62
úsek 2-Kabel1 (20) | Kabel1 | Levá | úsek 2 | 24.2 | 24.2726 | 231.927 | 0.0775194 | 230.052 | 0.0775194 | 6 | úsek 2-Kabel1 (20) | no | ((-642760.701683166,-1062781.86208363,230.051521359308),(-642747.840023877,-1062761.36287096,231.927489726758)) | 832.27 | 828.15
úsek 2-Kabel1 (21) | Kabel1 | Levá | úsek 2 | 11.4079 | 11.4192 | 231.818 | 0.0446118 | 231.309 | 0.0446118 | 5 | úsek 2-Kabel1 (21) | no | ((-642750.047266531,-1062740.12181913,231.30870884223),(-642747.823868779,-1062728.93269657,231.817634818387)) | 813.56 | 796.39
úsek 2-Kabel1 (22) | Kabel1 | Střed | úsek 2 | 133.365 | 133.371 | 232.583 | 0.0903425 | 232.324 | 0.000393293 | 41 | úsek 2-Kabel1 (22) | no | ((-642746.599956491,-1062844.70017377,232.323636626532),(-642642.691360597,-1062761.49821346,232.582785601073)) | 829.17 | 963.45
úsek 2-Kabel1 (23) | Kabel1 | Levá | úsek 2 | 10.99 | 11.1401 | 232.237 | 0.165863 | 230.414 | 0.165863 | 4 | úsek 2-Kabel1 (23) | no | ((-642791.819085737,-1062766.04424966,230.413948128709),(-642786.88148537,-1062756.22588918,232.236782605698)) | 800.57 | 806.4
úsek 2-Kabel2 | Kabel2 | Pravá | úsek 2 | 4.28 | 4.39672 | 232.069 | 0.409942 | 231.64 | 0.0214832 | 6 | úsek 2-Kabel2 | no | ((-642846.864547657,-1062751.46680991,231.639634215056),(-642843.472321362,-1062750.45351691,232.069004242582)) | 725.66 | 728.88
úsek 2-Kabel2 (24) | Kabel2 | Pravá | úsek 2 | 91.8642 | 92.1275 | 232.104 | 0.427757 | 230.153 | 0.00432572 | 30 | úsek 2-Kabel2 (24) | no | ((-642836.227877665,-1062785.01058108,230.153164227891),(-642757.208569454,-1062744.88372393,232.104478220498)) | 734.74 | 836.89
úsek 2-Kabel2 (25) | Kabel2 | Levá | úsek 2 | 7.5 | 7.50012 | 231.652 | 0.00558858 | 231.61 | 0.00558858 | 4 | úsek 2-Kabel2 (25) | no | ((-642843.508556028,-1062751.29108618,231.609634215056),(-642836.264112331,-1062749.34994334,231.651548582227)) | 728.81 | 734.67
úsek 2-Kabel2 (26) | Kabel2 | Pravá | úsek 2 | 0.8 | 0.896986 | 230.475 | 0.589147 | 230.122 | 0.0775194 | 3 | úsek 2-Kabel2 (26) | no | ((-642761.008271499,-1062782.61414985,230.121521359308),(-642760.583092679,-1062781.93648993,230.475009746892)) | 832.54 | 832.4
úsek 2-Kabel2 (27) | Kabel2 | Pravá | úsek 2 | 18.7582 | 18.8649 | 232.435 | 0.477519 | 231.674 | 0.0017272 | 12 | úsek 2-Kabel2 (27) | no | ((-642755.216314569,-1062761.43727725,231.67437263988),(-642747.347303751,-1062746.51558947,232.435063024408)) | 828.29 | 813.73
úsek 2-Kabel2 (28) | Kabel2 | Levá | úsek 2 | 24.2 | 24.2726 | 231.967 | 0.0775194 | 230.092 | 0.0775194 | 6 | úsek 2-Kabel2 (28) | no | ((-642760.701683166,-1062781.86208363,230.091521359308),(-642747.840023877,-1062761.36287096,231.967489726758)) | 832.27 | 828.15
úsek 2-Kabel2 (29) | Kabel2 | Levá | úsek 2 | 10.99 | 11.1401 | 232.277 | 0.165863 | 230.454 | 0.165863 | 4 | úsek 2-Kabel2 (29) | no | ((-642791.819085737,-1062766.04424966,230.453948128709),(-642786.88148537,-1062756.22588918,232.276782605698)) | 800.57 | 806.4

# IfcBuiltElement (179)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: yes; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsModifiedGraphics: no; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: trvalý stav
CZ_I1 - Označení stavebního objektu: SO 401; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Veřejné osvětlení; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Skupina elementů | Staničení od | Staničení do | Označení elementu | Označení položky | Označení šablony vlastností | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Klasifikace zemin / hornin = Další specifikace | Třída těžitelnosti
kabelové vedení-podkladní vrstva | 3.95455 | 3 | no | ((-642846.994947643,-1062751.61699291,231.559634215056),(-642843.437380791,-1062750.21433657,232.089004242582)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 725.56 | 728.95 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.147 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 3.95455 | 3 | no | ((-642846.994947643,-1062751.61699291,231.659634215056),(-642843.437380791,-1062750.21433657,232.189004242582)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 725.56 | 728.95 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.147 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 10.3245 | 3 | no | ((-642846.994947643,-1062751.61699291,231.559634215056),(-642843.437380791,-1062750.21433657,232.789004242582)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 725.56 | 728.95 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.176 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 8.50455 | 3 | no | ((-642846.994947643,-1062751.61699291,231.759634215056),(-642843.437380791,-1062750.21433657,232.789004242582)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 725.56 | 728.95 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.882 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 11.3802 | 3 | no | ((-642843.566790313,-1062751.70160465,231.449634215056),(-642836.154114237,-1062749.13261003,231.591548582227)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 728.7 | 734.88 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.4875 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 2.59373 | 11 | no | ((-642843.522791076,-1062751.3442121,231.549634215056),(-642836.249877284,-1062749.29681742,231.701548582227)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 728.79 | 734.7 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 7.5
kabelové vedení-chránička | 2.59373 | 11 | no | ((-642843.471027267,-1062751.53739726,231.549634215056),(-642836.198113475,-1062749.49000258,231.701548582227)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 728.89 | 734.8 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 7.5
trubní vedení-obetonování | 16.7293 | 3 | no | ((-642843.566790313,-1062751.70160465,231.549634215056),(-642836.154114237,-1062749.13261003,231.741548582227)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 728.7 | 734.88 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.59099 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 30.5327 | 3 | no | ((-642843.566790313,-1062751.70160465,231.449634215056),(-642836.154114237,-1062749.13261003,232.766548582227)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 728.7 | 734.88 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 6.21562 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 26.4577 | 3 | no | ((-642843.566790313,-1062751.70160465,231.699634215056),(-642836.154114237,-1062749.13261003,232.766548582227)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 728.7 | 734.88 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 4.99687 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 82.9766 | 3 | no | ((-642836.28352376,-1062785.13253616,230.073164227891),(-642757.116364562,-1062744.60045251,232.124478220498)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 734.64 | 836.93 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 3.21673 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 82.9766 | 3 | no | ((-642836.28352376,-1062785.13253616,230.173164227891),(-642757.116364562,-1062744.60045251,232.224478220498)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 734.64 | 836.93 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 3.21673 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 212.136 | 3 | no | ((-642836.28352376,-1062785.13253616,230.073164227891),(-642757.116364562,-1062744.60045251,232.824478220498)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 734.64 | 836.93 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 25.7338 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 175.233 | 3 | no | ((-642836.28352376,-1062785.13253616,230.273164227891),(-642757.116364562,-1062744.60045251,232.824478220498)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 734.64 | 836.93 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 19.3004 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 0.857891 | 3 | no | ((-642761.190392603,-1062782.68589878,230.041521359308),(-642760.468737567,-1062781.82222312,230.495009746892)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 832.2 | 832.67 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.028 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 0.857891 | 3 | no | ((-642761.190392603,-1062782.68589878,230.141521359308),(-642760.468737567,-1062781.82222312,230.595009746892)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 832.2 | 832.67 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.028 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 2.46789 | 3 | no | ((-642761.190392603,-1062782.68589878,230.041521359308),(-642760.468737567,-1062781.82222312,231.195009746892)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 832.2 | 832.67 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.224 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 2.00789 | 3 | no | ((-642761.190392603,-1062782.68589878,230.241521359308),(-642760.468737567,-1062781.82222312,231.195009746892)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 832.2 | 832.67 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.168 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 36.5244 | 3 | no | ((-642760.892275019,-1062782.08795988,229.931521359308),(-642747.480017042,-1062761.24328942,231.907489726758)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 827.93 | 832.68 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 1.573 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 8.34028 | 11 | no | ((-642760.748272285,-1062781.89131468,230.031521359308),(-642747.793434757,-1062761.33363991,232.017489726758)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 828.1 | 832.32 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 24.4
kabelové vedení-chránička | 8.34028 | 11 | no | ((-642760.578857305,-1062781.99760938,230.031521359308),(-642747.624019776,-1062761.43993462,232.017489726758)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 828.3 | 832.52 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 24.4
trubní vedení-obetonování | 53.7417 | 3 | no | ((-642760.892275019,-1062782.08795988,230.031521359308),(-642747.480017042,-1062761.24328942,232.057489726758)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 827.93 | 832.68 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.90693 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 94.9219 | 3 | no | ((-642760.892275019,-1062782.08795988,229.931521359308),(-642747.480017042,-1062761.24328942,233.082489726758)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 827.93 | 832.68 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 20.0557 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 82.4969 | 3 | no | ((-642760.892275019,-1062782.08795988,230.181521359308),(-642747.480017042,-1062761.24328942,233.082489726758)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 827.93 | 832.68 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 16.1232 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 17.0795 | 3 | no | ((-642755.436987814,-1062761.50902618,231.59437263988),(-642747.182574279,-1062746.29016482,232.455063024408)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 812.61 | 828.43 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.65817 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 17.0795 | 3 | no | ((-642755.436987814,-1062761.50902618,231.69437263988),(-642747.182574279,-1062746.29016482,232.555063024408)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 812.61 | 828.43 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.65817 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 43.8963 | 3 | no | ((-642755.436987814,-1062761.50902618,231.59437263988),(-642747.182574279,-1062746.29016482,233.155063024408)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 812.61 | 828.43 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 5.26536 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 36.2343 | 3 | no | ((-642755.436987814,-1062761.50902618,231.79437263988),(-642747.182574279,-1062746.29016482,233.155063024408)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 812.61 | 828.43 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 3.94902 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 9.93116 | 3 | no | ((-642754.767857552,-1062746.71950947,231.29870884223),(-642747.381296799,-1062740.06822163,232.067068908736)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 799 | 813 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.37 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 9.93116 | 3 | no | ((-642754.767857552,-1062746.71950947,231.39870884223),(-642747.381296799,-1062740.06822163,232.167068908736)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 812.11 | 814.47 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.376331 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 25.9429 | 3 | no | ((-642754.767857552,-1062746.71950947,231.29870884223),(-642747.381296799,-1062740.06822163,232.767068908736)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 799 | 813 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.98 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 21.3681 | 3 | no | ((-642754.767857552,-1062746.71950947,231.49870884223),(-642747.381296799,-1062740.06822163,232.767068908736)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 812.11 | 814.47 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.25799 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 17.2566 | 3 | no | ((-642750.267951733,-1062740.16567163,231.18870884223),(-642747.407018952,-1062728.84986407,231.797634818387)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 796.31 | 813.82 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.741513 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 3.93747 | 11 | no | ((-642750.101211803,-1062740.13253863,231.28870884223),(-642747.769923507,-1062728.92197707,231.907634818387)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 796.37 | 813.6 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11.4
kabelové vedení-chránička | 3.93747 | 11 | no | ((-642749.905047179,-1062740.09355863,231.28870884223),(-642747.573758883,-1062728.88299707,231.907634818387)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 796.44 | 813.72 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11.4
trubní vedení-obetonování | 25.3814 | 3 | no | ((-642750.267951733,-1062740.16567163,231.28870884223),(-642747.407018952,-1062728.84986407,231.947634818387)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 796.31 | 813.82 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.898927 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 45.5926 | 3 | no | ((-642750.267951733,-1062740.16567163,231.18870884223),(-642747.407018952,-1062728.84986407,232.972634818387)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 796.31 | 813.82 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 9.45429 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 39.5637 | 3 | no | ((-642750.267951733,-1062740.16567163,231.43870884223),(-642747.407018952,-1062728.84986407,232.972634818387)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 796.31 | 813.82 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 7.60051 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 120.103 | 3 | no | ((-642746.727676489,-1062844.8504361,232.243636626532),(-642642.601659809,-1062761.37857817,232.602785601073)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 829.16 | 963.46 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 4.66779 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 120.103 | 3 | no | ((-642746.727676489,-1062844.8504361,232.343636626532),(-642642.601659809,-1062761.37857817,232.702785601073)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 829.16 | 963.46 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 4.66779 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 307.305 | 3 | no | ((-642746.727676489,-1062844.8504361,232.243636626532),(-642642.601659809,-1062761.37857817,233.302785601073)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 829.16 | 963.46 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 37.3423 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 253.818 | 3 | no | ((-642746.727676489,-1062844.8504361,232.443636626532),(-642642.601659809,-1062761.37857817,233.302785601073)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 829.16 | 963.46 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 28.0067 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 123.027 | 3 | no | ((-642928.129321308,-1062720.44709615,231.370211737076),(-642799.838989557,-1062675.47021462,232.060317655463)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 623.66 | 763.39 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 4.78099 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 123.027 | 3 | no | ((-642928.129321308,-1062720.44709615,231.470211737076),(-642799.838989557,-1062675.47021462,232.160317655463)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 623.66 | 763.39 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 4.78099 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 314.757 | 3 | no | ((-642928.129321308,-1062720.44709615,231.370211737076),(-642799.838989557,-1062675.47021462,232.760317655463)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 623.66 | 763.39 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 38.2479 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 259.977 | 3 | no | ((-642928.129321308,-1062720.44709615,231.570211737076),(-642799.838989557,-1062675.47021462,232.760317655463)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 623.66 | 763.39 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 28.6859 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 2.43863 | 3 | no | ((-642800.101503476,-1062722.902913,231.93849359712),(-642799.214838271,-1062720.21560869,232.087667946286)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 763.16 | 764.48 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.0920688 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 2.43863 | 3 | no | ((-642800.101503476,-1062722.902913,232.03849359712),(-642799.214838271,-1062720.21560869,232.187667946286)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 763.16 | 764.48 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.0920688 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 6.61138 | 3 | no | ((-642800.101503476,-1062722.902913,231.93849359712),(-642799.214838271,-1062720.21560869,232.787667946286)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 763.16 | 764.48 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.736551 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 5.41916 | 3 | no | ((-642800.101503476,-1062722.902913,232.13849359712),(-642799.214838271,-1062720.21560869,232.787667946286)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 763.16 | 764.48 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.552413 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 21.1651 | 3 | no | ((-642820.615042042,-1062727.51488674,231.789020545741),(-642799.214838271,-1062722.85241955,232.087667946286)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 743.23 | 764.48 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.819965 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 21.1651 | 3 | no | ((-642820.615042042,-1062727.51488674,231.889020545741),(-642799.214838271,-1062722.85241955,232.187667946286)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 743.23 | 764.48 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.819965 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 54.5109 | 3 | no | ((-642820.615042042,-1062727.51488674,231.789020545741),(-642799.214838271,-1062722.85241955,232.787667946286)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 743.23 | 764.48 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 6.55972 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 44.9835 | 3 | no | ((-642820.615042042,-1062727.51488674,231.989020545741),(-642799.214838271,-1062722.85241955,232.787667946286)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 743.23 | 764.48 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 4.91979 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 29.2301 | 3 | no | ((-642856.541255524,-1062736.22628493,231.385111046846),(-642848.131924196,-1062718.20790792,231.53866694901)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 712.56 | 714.02 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 1.261 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 6.6797 | 3 | no | ((-642856.202599588,-1062736.15780827,231.485111046846),(-642848.28752287,-1062718.35694536,231.64866694901)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 712.91 | 713.85 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 19.4
kabelové vedení-chránička | 6.6797 | 3 | no | ((-642856.385656851,-1062736.0772475,231.485111046846),(-642848.470580133,-1062718.27638458,231.64866694901)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 712.72 | 713.64 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 19.4
trubní vedení-obetonování | 43.0226 | 3 | no | ((-642856.541255524,-1062736.22628493,231.485111046846),(-642848.131924196,-1062718.20790792,231.68866694901)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 712.56 | 714.02 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.52869 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 76.3476 | 3 | no | ((-642856.541255524,-1062736.22628493,231.385111046846),(-642848.131924196,-1062718.20790792,232.71366694901)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 712.56 | 714.02 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 16.0778 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 66.3226 | 3 | no | ((-642856.541255524,-1062736.22628493,231.635111046846),(-642848.131924196,-1062718.20790792,232.71366694901)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 712.56 | 714.02 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 12.9253 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 23.7841 | 3 | no | ((-642856.54352113,-1062752.9327861,231.495111046846),(-642847.029838423,-1062736.02488299,232.151700152584)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 712.69 | 725.66 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.916593 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 23.7841 | 3 | no | ((-642856.54352113,-1062752.9327861,231.595111046846),(-642847.029838423,-1062736.02488299,232.251700152584)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 712.69 | 725.66 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.916593 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 60.9378 | 3 | no | ((-642856.54352113,-1062752.9327861,231.495111046846),(-642847.029838423,-1062736.02488299,232.851700152584)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 712.69 | 725.66 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 7.33274 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 50.3225 | 3 | no | ((-642856.54352113,-1062752.9327861,231.695111046846),(-642847.029838423,-1062736.02488299,232.851700152584)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 712.69 | 725.66 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 5.49956 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 96.1189 | 3 | no | ((-642946.666045165,-1062718.46317468,231.611213587205),(-642847.798666079,-1062677.6811948,232.44542304413)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 607.36 | 714.23 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 3.735 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 96.1189 | 3 | no | ((-642946.666045165,-1062718.46317468,231.711213587205),(-642847.798666079,-1062677.6811948,232.54542304413)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 607.36 | 714.23 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 3.735 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 246.009 | 3 | no | ((-642946.666045165,-1062718.46317468,231.611213587205),(-642847.798666079,-1062677.6811948,233.14542304413)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 607.36 | 714.23 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 29.88 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 203.183 | 3 | no | ((-642946.666045165,-1062718.46317468,231.811213587205),(-642847.798666079,-1062677.6811948,233.14542304413)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 607.36 | 714.23 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 22.41 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 19.6323 | 3 | no | ((-642800.04068951,-1062720.23057228,231.417970612706),(-642795.12549813,-1062707.74786478,231.732785640429)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 763.14 | 773.42 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.845 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 4.48249 | 11 | no | ((-642799.880266826,-1062720.10813614,231.517970612706),(-642795.474653383,-1062707.80411923,231.842785640429)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 763.32 | 773.08 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 13
kabelové vedení-chránička | 4.48249 | 11 | no | ((-642799.691534258,-1062720.17431784,231.517970612706),(-642795.285920814,-1062707.87030093,231.842785640429)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 763.54 | 773.27 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 13
trubní vedení-obetonování | 28.8843 | 3 | no | ((-642800.04068951,-1062720.23057228,231.517970612706),(-642795.12549813,-1062707.74786478,231.882785640429)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 763.14 | 773.42 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.02438 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 51.7098 | 3 | no | ((-642800.04068951,-1062720.23057228,231.417970612706),(-642795.12549813,-1062707.74786478,232.907785640429)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 763.14 | 773.42 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 10.7738 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 44.8848 | 3 | no | ((-642800.04068951,-1062720.23057228,231.667970612706),(-642795.12549813,-1062707.74786478,232.907785640429)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 763.14 | 773.42 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 8.66125 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 28.3988 | 3 | no | ((-642795.597329553,-1062718.09660908,231.742785640429),(-642767.049105132,-1062706.46364433,232.263272238583)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 772.97 | 788.19 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.0994 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 28.3988 | 3 | no | ((-642795.597329553,-1062718.09660908,231.842785640429),(-642767.049105132,-1062706.46364433,232.363272238583)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 772.97 | 788.19 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 1.0994 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 72.8647 | 3 | no | ((-642795.597329553,-1062718.09660908,231.742785640429),(-642767.049105132,-1062706.46364433,232.963272238583)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 772.97 | 788.19 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 8.79519 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 60.1602 | 3 | no | ((-642795.597329553,-1062718.09660908,231.942785640429),(-642767.049105132,-1062706.46364433,232.963272238583)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 772.97 | 788.19 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 6.59639 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 18.6374 | 3 | no | ((-642767.291488277,-1062728.75865883,231.194753000953),(-642749.968370444,-1062717.84412064,232.183439887227)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 789.38 | 796.27 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.719593 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 18.6374 | 3 | no | ((-642767.291488277,-1062728.75865883,231.294753000953),(-642749.968370444,-1062717.84412064,232.283439887227)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 789.38 | 796.27 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.719593 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 47.9518 | 3 | no | ((-642767.291488277,-1062728.75865883,231.194753000953),(-642749.968370444,-1062717.84412064,232.883439887227)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 789.38 | 796.27 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 5.75674 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 39.5762 | 3 | no | ((-642767.291488277,-1062728.75865883,231.394753000953),(-642749.968370444,-1062717.84412064,232.883439887227)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 789.38 | 796.27 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 4.31756 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 64.3316 | 3 | no | ((-642750.024268612,-1062728.7413361,230.537912101442),(-642684.083647163,-1062713.25008913,231.683718116628)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 795.94 | 846.83 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 2.492 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 64.3316 | 3 | no | ((-642750.024268612,-1062728.7413361,230.637912101442),(-642684.083647163,-1062713.25008913,231.783718116628)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 795.94 | 846.83 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 2.492 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 164.502 | 3 | no | ((-642750.024268612,-1062728.7413361,230.537912101442),(-642684.083647163,-1062713.25008913,232.383718116628)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 795.94 | 846.83 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 19.936 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 135.882 | 3 | no | ((-642750.024268612,-1062728.7413361,230.737912101442),(-642684.083647163,-1062713.25008913,232.383718116628)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 795.94 | 846.83 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 14.952 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 12.133 | 3 | no | ((-642684.152193579,-1062713.74536823,230.427912101442),(-642676.138617607,-1062712.00476274,230.719198145425)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 844.63 | 851.01 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.52 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 2.76579 | 11 | no | ((-642684.128887798,-1062713.3788617,230.527912101442),(-642676.189341955,-1062712.17315764,230.829198145425)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 844.77 | 850.7 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 8
kabelové vedení-chránička | 2.76579 | 11 | no | ((-642684.101469231,-1062713.57697334,230.527912101442),(-642676.161923388,-1062712.37126928,230.829198145425)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 844.94 | 850.87 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 8
trubní vedení-obetonování | 17.8374 | 3 | no | ((-642684.152193579,-1062713.74536823,230.527912101442),(-642676.138617607,-1062712.00476274,230.869198145425)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 844.63 | 851.01 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.630389 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 32.4605 | 3 | no | ((-642684.152193579,-1062713.74536823,230.427912101442),(-642676.138617607,-1062712.00476274,231.894198145425)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 844.63 | 851.01 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 6.63 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 28.1355 | 3 | no | ((-642684.152193579,-1062713.74536823,230.677912101442),(-642676.138617607,-1062712.00476274,231.894198145425)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 844.63 | 851.01 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 5.33 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 53.9233 | 3 | no | ((-642676.207164023,-1062716.77470418,230.157586380052),(-642619.887986054,-1062708.84036,231.220795199216)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 850.59 | 898.2 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 2.09169 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 53.9233 | 3 | no | ((-642676.207164023,-1062716.77470418,230.257586380052),(-642619.887986054,-1062708.84036,231.320795199216)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 850.59 | 898.2 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 2.09169 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-výkop rýhy | 138.081 | 3 | no | ((-642676.207164023,-1062716.77470418,230.157586380052),(-642619.887986054,-1062708.84036,231.920795199216)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 850.59 | 898.2 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 16.7335 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 114.036 | 3 | no | ((-642676.207164023,-1062716.77470418,230.357586380052),(-642619.887986054,-1062708.84036,231.920795199216)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 850.59 | 898.2 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 12.5501 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 16.8102 | 3 | no | ((-642792.198776656,-1062766.14533793,230.293948128709),(-642786.680472531,-1062756.03494467,232.216782605698)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 775.2 | 806.59 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.71435 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 3.81786 | 11 | no | ((-642791.868222209,-1062766.06896013,230.393948128709),(-642786.832348899,-1062756.20117871,232.326782605698)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 800.53 | 806.44 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11.1
kabelové vedení-chránička | 3.81786 | 11 | no | ((-642792.046900289,-1062765.97910389,230.393948128709),(-642787.011026978,-1062756.11132247,232.326782605698)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 800.36 | 806.27 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P10 | 127;0;127 | CZ_S1 - Reference: D.4.1.3; Materiál: PVC; specifikace: nerelevantni; podrobná specifikace: DN110; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11.1
trubní vedení-obetonování | 24.6751 | 3 | no | ((-642792.198776656,-1062766.14533793,230.393948128709),(-642786.680472531,-1062756.03494467,232.366782605698)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 775.2 | 806.59 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.865997 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 44.1642 | 3 | no | ((-642792.198776656,-1062766.14533793,230.293948128709),(-642786.680472531,-1062756.03494467,233.391782605698)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 775.2 | 806.59 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 9.10796 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 38.3442 | 3 | no | ((-642792.198776656,-1062766.14533793,230.543948128709),(-642786.680472531,-1062756.03494467,233.391782605698)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 775.2 | 806.59 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 7.32209 | objemová metoda | nerelevantni | 1
Portály-stojky | 3.96671 | 7 | yes | ((-642815.334139019,-1062715.47338829,232.732770224337),(-642814.985864012,-1062714.85841536,242.832770224337)) | 8 | Portály-stojky | Barva_8 | Portály | 745.95 | 746.25 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 3.96671 | 7 | yes | ((-642851.508237624,-1062707.72955196,232.376106280175),(-642851.078444543,-1062707.09932093,242.476106280175)) | 8 | Portály-stojky | Barva_8 | Portály | 706.61 | 706.88 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 3.96671 | 7 | yes | ((-642888.824219679,-1062693.06476357,232.291524424204),(-642888.366956451,-1062692.43318429,242.391524424204)) | 8 | Portály-stojky | Barva_8 | Portály | 666.54 | 666.8 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 3.96671 | 7 | yes | ((-642928.20577811,-1062675.75490407,232.090211737076),(-642927.738544739,-1062675.12343037,242.190211737076)) | 8 | Portály-stojky | Barva_8 | Portály | 623.54 | 623.8 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 3.96671 | 7 | yes | ((-642738.811934134,-1062727.24999524,232.732770224337),(-642738.481353389,-1062726.64014192,242.832770224337)) | 8 | Portály-stojky | Barva_8 | Portály | 800.37 | 800.93 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 3.96671 | 8 | yes | ((-642826.97935103,-1062748.16491569,232.787984074301),(-642826.504005858,-1062747.53378859,242.887984074301)) | 8 | Portály-stojky | Barva_8 | Portály | 742.73 | 743.06 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 3.96671 | 8 | yes | ((-642757.338155933,-1062785.09840416,230.873164227891),(-642756.873693424,-1062784.46686665,240.973164227891)) | 8 | Portály-stojky | Barva_8 | Portály | 836.61 | 837 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.92314 | 10 | yes | ((-642787.774842058,-1062757.56493865,233.391782605698),(-642786.166806762,-1062754.79698346,243.577251875609)) | 8 | Portály-stojky | Barva_8 | Portály | 799.61 | 801.37 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
