Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 2

# IfcBuiltElement (179)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Skupina elementů | Staničení od | Staničení do | Označení elementu | Označení položky | Označení šablony vlastností | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Klasifikace zemin / hornin = Další specifikace | Třída těžitelnosti
Portály-stojky | 4.39129 | 11 | yes | ((-642947.56865759,-1062679.70365228,232.411213587038),(-642946.45755718,-1062677.72073195,242.639417491904)) | 8 | Portály-stojky | Barva_8 | Portály | 607.14 | 607.41 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642913.780782802,-1062693.64063607,233.145423043985),(-642912.669682391,-1062691.65771574,243.373626948851)) | 8 | Portály-stojky | Barva_8 | Portály | 643.69 | 643.96 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642878.955258082,-1062707.95373992,232.836738373153),(-642877.839740535,-1062705.9724717,243.064942278019)) | 8 | Portály-stojky | Barva_8 | Portály | 681.34 | 681.62 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 8 | yes | ((-642848.664146974,-1062720.21848789,232.753363471944),(-642847.718003226,-1062718.18401276,242.98156737681)) | 8 | Portály-stojky | Barva_8 | Portály | 714.12 | 714.38 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642821.053948173,-1062727.5366764,232.729727523401),(-642820.448060473,-1062725.45023838,242.957931428267)) | 8 | Portály-stojky | Barva_8 | Portály | 743.19 | 743.53 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642748.071376363,-1062763.02361035,233.133632551879),(-642746.454380187,-1062761.35393641,243.361836456744)) | 8 | Portály-stojky | Barva_8 | Portály | 828.98 | 829.25 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642697.668667595,-1062807.77711425,233.29156763386),(-642696.231668219,-1062805.96220795,243.519771538726)) | 8 | Portály-stojky | Barva_8 | Portály | 896.77 | 897.03 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642671.040241647,-1062827.64632309,233.213935224805),(-642669.626655865,-1062825.81576279,243.442139129671)) | 8 | Portály-stojky | Barva_8 | Portály | 930.16 | 930.41 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642643.882199512,-1062846.44116489,233.043636626564),(-642642.542955481,-1062844.56501107,243.27184053143)) | 8 | Portály-stojky | Barva_8 | Portály | 963.35 | 963.6 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642799.52578743,-1062724.12259416,232.787667946424),(-642797.680761734,-1062722.73154645,243.01587185129)) | 8 | Portály-stojky | Barva_8 | Portály | 764.29 | 766.17 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642768.213428706,-1062719.79788283,232.883439887315),(-642767.028007841,-1062717.84480643,243.111643792181)) | 8 | Portály-stojky | Barva_8 | Portály | 799 | 800 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642699.633340518,-1062721.97373948,232.076624309644),(-642699.025399391,-1062719.88741909,242.30482821451)) | 8 | Portály-stojky | Barva_8 | Portály | 836.96 | 838.77 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642659.935493414,-1062716.46638664,231.3654101789),(-642659.327552287,-1062714.38006625,241.593614083765)) | 8 | Portály-stojky | Barva_8 | Portály | 866.24 | 868.07 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642620.194760314,-1062710.8686967,230.957586380187),(-642619.586819187,-1062708.78237631,241.185790285053)) | 8 | Portály-stojky | Barva_8 | Portály | 897.68 | 899.53 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 7 | yes | ((-642724.555975488,-1062784.71990408,233.274767511059),(-642722.975014129,-1062783.01717297,243.502971415924)) | 8 | Portály-stojky | Barva_8 | Portály | 861.17 | 861.45 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-stojky | 4.39129 | 10 | yes | ((-642755.477557377,-1062746.6917658,232.394372639712),(-642753.492960057,-1062745.58519046,242.622576544578)) | 8 | Portály-stojky | Barva_8 | Portály | 811.76 | 813.72 | Stojky | 75H141 | I1+S2+E1+Z1+M1+F1 | P1 | 128;128;128 | CZ_S2 - Specifikace: žárově zinkovaný - provedení "Pardubice"; Podrobná specifikace: vč. svítidla, elektro výzbroje, bet. základu; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: stožár VO; Stavební výrobek: stožár uliční bezpaticový; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
Portály-vybavení elektro | 5.52 | 10 | yes | ((-642847.628000707,-1062750.66587725,232.360839939583),(-642846.391244002,-1062750.06551665,233.960839939583)) | 40 | Portály-vybavení elektro | Barva_40 | Portály | 724.97 | 726.04 | Vybavení elektro | 743711 | I1+S2+E1+Z1+M4+F1 | P1 | 255;165;0 | CZ_S2 - Specifikace: nerezový pilíř, 1200x1600x300, IP43/20, hl. jistič 3x32A, 4 zapojené vývody; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: pilíř; Stavební výrobek: elektrický rozvaděč; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-výkop rýhy | 67.1931 | 5 | no | ((-642848.589567353,-1062725.71852541,231.54866694901),(-642820.546107571,-1062718.12251629,232.751776772189)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 713.51 | 743.25 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 8.10367 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 55.4746 | 5 | no | ((-642848.589567353,-1062725.71852541,231.74866694901),(-642820.546107571,-1062718.12251629,232.751776772189)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 713.51 | 743.25 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 6.07775 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 26.5818 | 10 | yes | ((-642848.589569352,-1062725.71854723,231.438666965103),(-642820.54610957,-1062718.12253811,232.05336348795)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 713.51 | 743.25 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.01277 | objemová metoda | CZ_S1 - Reference: D.4.1.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 26.5818 | 14 | yes | ((-642848.589563745,-1062725.71850745,231.53866694901),(-642820.546103962,-1062718.12249833,232.153363471857)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 713.51 | 743.25 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 1.01277 | objemová metoda | CZ_M6 - Tloušťka: 0.1; CZ_S2 - Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.4.1.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4
zemní práce-zásyp rýhy | 4 | 8 | yes | ((-642821.085037611,-1062726.05069902,232.229727523401),(-642820.085037611,-1062725.05069902,232.729727523401)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 742.61 | 743.87 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 6 | yes | ((-642821.085037611,-1062726.05069902,231.229727523401),(-642820.085037611,-1062725.05069902,232.729727523401)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 742.61 | 743.87 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642848.362855863,-1062718.80202264,232.253363471944),(-642847.362855863,-1062717.80202264,232.753363471944)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 713.55 | 714.88 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642848.362855863,-1062718.80202264,231.253363471944),(-642847.362855863,-1062717.80202264,232.753363471944)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 713.55 | 714.88 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642878.486970705,-1062706.59834887,232.336738373153),(-642877.486970705,-1062705.59834887,232.836738373153)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 680.91 | 682.22 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642878.486970705,-1062706.59834887,231.336738373153),(-642877.486970705,-1062705.59834887,232.836738373153)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 680.91 | 682.22 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642913.316865483,-1062692.28339615,232.645423043985),(-642912.316865483,-1062691.28339615,233.145423043985)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 643.26 | 644.56 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642913.316865483,-1062692.28339615,231.645423043985),(-642912.316865483,-1062691.28339615,233.145423043985)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 643.26 | 644.56 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642947.104740271,-1062678.34641235,231.911213587038),(-642946.104740271,-1062677.34641235,232.411213587038)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 606.71 | 608.01 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642947.104740271,-1062678.34641235,230.911213587038),(-642946.104740271,-1062677.34641235,232.411213587038)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 606.71 | 608.01 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642827.332086875,-1062748.53889453,232.287984074301),(-642826.332086875,-1062747.53889453,232.787984074301)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 742.27 | 743.42 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642827.332086875,-1062748.53889453,231.287984074301),(-642826.332086875,-1062747.53889453,232.787984074301)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 742.27 | 743.42 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642787.47082441,-1062756.68096106,232.891782605698),(-642786.47082441,-1062755.68096106,233.391782605698)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 777.58 | 801.18 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642787.47082441,-1062756.68096106,231.891782605698),(-642786.47082441,-1062755.68096106,233.391782605698)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 777.58 | 801.18 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642757.691415056,-1062785.47444624,230.373164227891),(-642756.691415056,-1062784.47444624,230.873164227891)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 836.19 | 837.57 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642757.691415056,-1062785.47444624,229.373164227891),(-642756.691415056,-1062784.47444624,230.873164227891)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 836.19 | 837.57 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642643.191360597,-1062845.20017377,232.543636626564),(-642642.191360597,-1062844.20017377,233.043636626564)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 962.76 | 964.15 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642643.191360597,-1062845.20017377,231.543636626564),(-642642.191360597,-1062844.20017377,233.043636626564)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 962.76 | 964.15 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642670.274849592,-1062826.4536722,232.713935224805),(-642669.274849592,-1062825.4536722,233.213935224805)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 929.58 | 930.99 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642670.274849592,-1062826.4536722,231.713935224805),(-642669.274849592,-1062825.4536722,233.213935224805)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 929.58 | 930.99 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642696.879722323,-1062806.6009413,232.79156763386),(-642695.879722323,-1062805.6009413,233.29156763386)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 896.16 | 897.57 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642696.879722323,-1062806.6009413,231.79156763386),(-642695.879722323,-1062805.6009413,233.29156763386)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 896.16 | 897.57 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642723.621311179,-1062783.66046667,232.774767511059),(-642722.621311179,-1062782.66046667,233.274767511059)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 860.67 | 862.09 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642723.621311179,-1062783.66046667,231.774767511059),(-642722.621311179,-1062782.66046667,233.274767511059)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 860.67 | 862.09 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642747.099956491,-1062761.99821346,232.633632551879),(-642746.099956491,-1062760.99821346,233.133632551879)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 828.46 | 829.89 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642747.099956491,-1062761.99821346,231.633632551879),(-642746.099956491,-1062760.99821346,233.133632551879)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 828.46 | 829.89 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642754.118438388,-1062747.04463181,231.894372639712),(-642753.118438388,-1062746.04463181,232.394372639712)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 812.99 | 814.42 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642754.118438388,-1062747.04463181,230.894372639712),(-642753.118438388,-1062746.04463181,232.394372639712)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 812.99 | 814.42 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642739.176754882,-1062727.23723855,232.232770224337),(-642738.176754882,-1062726.23723855,232.732770224337)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 799.73 | 801.11 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642739.176754882,-1062727.23723855,231.232770224337),(-642738.176754882,-1062726.23723855,232.732770224337)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 799.73 | 801.11 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642699.996304793,-1062720.48799186,231.576624309644),(-642698.996304793,-1062719.48799186,232.076624309644)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 836.23 | 837.76 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642699.996304793,-1062720.48799186,230.576624309644),(-642698.996304793,-1062719.48799186,232.076624309644)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 836.23 | 837.76 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642620.557724589,-1062709.38294908,230.457586380187),(-642619.557724589,-1062708.38294908,230.957586380187)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 896.9 | 898.53 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642620.557724589,-1062709.38294908,229.457586380187),(-642619.557724589,-1062708.38294908,230.957586380187)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 896.9 | 898.53 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642660.298457689,-1062714.98063902,230.8654101789),(-642659.298457689,-1062713.98063902,231.3654101789)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 865.48 | 867.06 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642660.298457689,-1062714.98063902,229.8654101789),(-642659.298457689,-1062713.98063902,231.3654101789)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 865.48 | 867.06 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642767.675867575,-1062718.47373261,232.383439887315),(-642766.675867575,-1062717.47373261,232.883439887315)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 799 | 800 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642767.675867575,-1062718.47373261,231.383439887315),(-642766.675867575,-1062717.47373261,232.883439887315)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 799 | 800 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642799.888690318,-1062723.37984054,232.287667946424),(-642798.888690318,-1062722.37984054,232.787667946424)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 763.73 | 764.89 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642799.888690318,-1062723.37984054,231.287667946424),(-642798.888690318,-1062722.37984054,232.787667946424)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 763.73 | 764.89 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642815.696999753,-1062715.87261692,232.232770224337),(-642814.696999753,-1062714.87261692,232.732770224337)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 745.46 | 746.77 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642815.696999753,-1062715.87261692,231.232770224337),(-642814.696999753,-1062714.87261692,232.732770224337)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 745.46 | 746.77 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642851.863664808,-1062708.11231159,231.876106280175),(-642850.863664808,-1062707.11231159,232.376106280175)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 706.1 | 707.41 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642851.863664808,-1062708.11231159,230.876106280175),(-642850.863664808,-1062707.11231159,232.376106280175)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 706.1 | 707.41 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642889.177869003,-1062693.44218326,231.791524424204),(-642888.177869003,-1062692.44218326,232.291524424204)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 666.02 | 667.32 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642889.177869003,-1062693.44218326,230.791524424204),(-642888.177869003,-1062692.44218326,232.291524424204)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 666.02 | 667.32 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 4 | 5 | yes | ((-642928.558896202,-1062676.13041857,231.590211737076),(-642927.558896202,-1062675.13041857,232.090211737076)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 623.01 | 624.31 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.5 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8 | 5 | yes | ((-642928.558896202,-1062676.13041857,230.590211737076),(-642927.558896202,-1062675.13041857,232.090211737076)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 623.01 | 624.31 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.5 | objemová metoda | nerelevantni | 1
