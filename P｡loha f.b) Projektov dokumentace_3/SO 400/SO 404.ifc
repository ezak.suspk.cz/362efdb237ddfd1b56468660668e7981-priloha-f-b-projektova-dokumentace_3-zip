Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 2

# IfcBuiltElement (235)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Skupina elementů | Staničení od | Staničení do | Označení elementu | Označení položky | Označení šablony vlastností | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Klasifikace zemin / hornin = Další specifikace | Třída těžitelnosti
odvodnění-podkladní beton | 13.2502 | 1 | no | ((-640751.870973595,-1063760.95005788,236.850067694341),(-640740.584293991,-1063755.92089942,236.968651196249)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 3063.74 | 3075.67 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.3 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 4.70612 | 1 | no | ((-640751.798714693,-1063760.77606786,236.900067694341),(-640740.654177617,-1063756.09391647,237.093651196249)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 3063.74 | 3075.67 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 12
trubní vedení-obetonování | 21.1937 | 1 | no | ((-640751.870973595,-1063760.95005788,236.900067694341),(-640740.584293991,-1063755.92089942,237.168651196249)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 3063.74 | 3075.67 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.05534 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 26.3752 | 1 | no | ((-640751.870973595,-1063760.95005788,236.850067694341),(-640740.584293991,-1063755.92089942,237.493651196249)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3063.74 | 3075.67 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 3.45 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 20.1252 | 1 | no | ((-640751.870973595,-1063760.95005788,237.100067694341),(-640740.584293991,-1063755.92089942,237.493651196249)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3063.74 | 3075.67 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.95 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 3.67065 | 1 | no | ((-640740.742696878,-1063762.81119107,236.858413335698),(-640737.14348187,-1063760.55568049,237.025067694341)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3075.67 | 3079.61 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.14 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 3.23565 | 1 | no | ((-640740.742696878,-1063762.81119107,236.958413335698),(-640737.14348187,-1063760.55568049,237.075067694341)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3075.67 | 3079.61 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.07 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 7.15065 | 1 | no | ((-640740.742696878,-1063762.81119107,236.858413335698),(-640737.14348187,-1063760.55568049,237.425067694341)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3075.67 | 3079.61 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.7 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 5.84565 | 1 | no | ((-640740.742696878,-1063762.81119107,237.008413335698),(-640737.14348187,-1063760.55568049,237.425067694341)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3075.67 | 3079.61 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.49 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 88.1511 | 1 | no | ((-640732.775852622,-1063793.88477702,236.12757401006),(-640639.293928023,-1063764.51572315,236.907218831568)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3084.47 | 3181.59 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 3.42531 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 78.3295 | 1 | no | ((-640732.775852622,-1063793.88477702,236.22757401006),(-640639.293928023,-1063764.51572315,236.957218831568)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3084.47 | 3181.59 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 1.71265 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 166.724 | 1 | no | ((-640732.775852622,-1063793.88477702,236.12757401006),(-640639.293928023,-1063764.51572315,237.307218831568)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3084.47 | 3181.59 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 17.1265 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 137.259 | 1 | no | ((-640732.775852622,-1063793.88477702,236.27757401006),(-640639.293928023,-1063764.51572315,237.307218831568)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3084.47 | 3181.59 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 11.9886 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 43.2704 | 1 | no | ((-640614.713461941,-1063806.98570501,235.763542830684),(-640567.29418751,-1063798.9075839,236.101680900182)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3206.63 | 3254.27 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.68 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 38.4354 | 1 | no | ((-640614.713461941,-1063806.98570501,235.863542830684),(-640567.29418751,-1063798.9075839,236.151680900182)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3206.63 | 3254.27 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.84 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 81.9504 | 1 | no | ((-640614.713461941,-1063806.98570501,235.763542830684),(-640567.29418751,-1063798.9075839,236.501680900182)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3206.63 | 3254.27 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 8.4 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 67.4454 | 1 | no | ((-640614.713461941,-1063806.98570501,235.913542830684),(-640567.29418751,-1063798.9075839,236.501680900182)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3206.63 | 3254.27 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 5.88 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 13.2501 | 1 | no | ((-640567.34810473,-1063808.4946614,235.628635508906),(-640555.374257559,-1063806.56413896,235.738542830684)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 3254.27 | 3266.18 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.3 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 4.70611 | 1 | no | ((-640567.324317721,-1063808.30835555,235.678635508906),(-640555.395385302,-1063806.75012398,235.863542830684)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 3254.27 | 3266.18 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 12
trubní vedení-obetonování | 21.1936 | 1 | no | ((-640567.34810473,-1063808.4946614,235.678635508906),(-640555.374257559,-1063806.56413896,235.938542830684)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 3254.27 | 3266.18 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.05534 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 26.3751 | 1 | no | ((-640567.34810473,-1063808.4946614,235.628635508906),(-640555.374257559,-1063806.56413896,236.263542830684)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3254.27 | 3266.18 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 3.45 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 20.1251 | 1 | no | ((-640567.34810473,-1063808.4946614,235.878635508906),(-640555.374257559,-1063806.56413896,236.263542830684)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3254.27 | 3266.18 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.95 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 442.425 | 1 | no | ((-640555.42214711,-1063812.78620255,233.035866865151),(-640080.268423123,-1063709.58964861,235.803635508907)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3266.18 | 3755.07 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 17.2025 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 393.24 | 1 | no | ((-640555.42214711,-1063812.78620255,233.135866865151),(-640080.268423123,-1063709.58964861,235.853635508907)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3266.18 | 3755.07 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 8.60125 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 835.905 | 1 | no | ((-640555.42214711,-1063812.78620255,233.035866865151),(-640080.268423123,-1063709.58964861,236.203635508907)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3266.18 | 3755.07 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 86.0125 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 688.35 | 1 | no | ((-640555.42214711,-1063812.78620255,233.185866865151),(-640080.268423123,-1063709.58964861,236.203635508907)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3266.18 | 3755.07 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 60.2087 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 17.6502 | 1 | no | ((-640080.423815254,-1063709.98522198,232.880549345031),(-640065.348827315,-1063703.66978484,233.010866865151)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 3755.07 | 3771.07 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.4 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 6.26685 | 1 | no | ((-640080.355259902,-1063709.81070432,232.930549345031),(-640065.417382667,-1063703.8443025,233.135866865151)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 3755.07 | 3771.07 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 16
trubní vedení-obetonování | 28.1996 | 1 | no | ((-640080.423815254,-1063709.98522198,232.930549345031),(-640065.348827315,-1063703.66978484,233.210866865151)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 3755.07 | 3771.07 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.40712 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 34.9752 | 1 | no | ((-640080.423815254,-1063709.98522198,232.880549345031),(-640065.348827315,-1063703.66978484,233.535866865151)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3755.07 | 3771.07 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 4.6 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 26.7252 | 1 | no | ((-640080.423815254,-1063709.98522198,233.130549345031),(-640065.348827315,-1063703.66978484,233.535866865151)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3755.07 | 3771.07 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.6 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 8.62008 | 1 | no | ((-640065.504219446,-1063704.06535821,232.907860817466),(-640056.534021341,-1063700.26612074,233.055549345031)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3771.07 | 3780.57 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.3325 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 7.63508 | 1 | no | ((-640065.504219446,-1063704.06535821,233.007860817466),(-640056.534021341,-1063700.26612074,233.105549345031)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3771.07 | 3780.57 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.16625 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 16.5001 | 1 | no | ((-640065.504219446,-1063704.06535821,232.907860817466),(-640056.534021341,-1063700.26612074,233.455549345031)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3771.07 | 3780.57 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.6625 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 13.5451 | 1 | no | ((-640065.504219446,-1063704.06535821,233.057860817466),(-640056.534021341,-1063700.26612074,233.455549345031)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3771.07 | 3780.57 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.16375 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 290.773 | 1 | no | ((-640052.00818706,-1063698.76374432,231.259793807208),(-639750.329135783,-1063582.82978159,232.982761592433)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3785.57 | 4108.88 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 11.305 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 258.438 | 1 | no | ((-640052.00818706,-1063698.76374432,231.359793807208),(-639750.329135783,-1063582.82978159,233.032761592433)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3785.57 | 4108.88 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 5.6525 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 549.453 | 1 | no | ((-640052.00818706,-1063698.76374432,231.259793807208),(-639750.329135783,-1063582.82978159,233.382761592433)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3785.57 | 4108.88 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 56.525 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 452.448 | 1 | no | ((-640052.00818706,-1063698.76374432,231.409793807208),(-639750.329135783,-1063582.82978159,233.382761592433)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3785.57 | 4108.88 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 39.5675 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 238.947 | 1 | no | ((-639745.682602856,-1063581.61737545,229.958810983767),(-639487.804509224,-1063520.06005331,231.334609939294)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 4113.9 | 4380 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 9.28955 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 212.37 | 1 | no | ((-639745.682602856,-1063581.61737545,230.058810983767),(-639487.804509224,-1063520.06005331,231.384609939294)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 4113.9 | 4380 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 4.64477 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 451.559 | 1 | no | ((-639745.682602856,-1063581.61737545,229.958810983767),(-639487.804509224,-1063520.06005331,231.734609939294)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4113.9 | 4380 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 46.4477 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 371.83 | 1 | no | ((-639745.682602856,-1063581.61737545,230.108810983767),(-639487.804509224,-1063520.06005331,231.734609939294)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4113.9 | 4380 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 32.5134 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-643497.333690105,-1062421.81509355,229.593749999993),(-643496.233690105,-1062420.71509355,230.293749999993)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 0.28 | 0.5 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-643497.783690105,-1062422.26509355,229.593749999993),(-643495.783690105,-1062420.26509355,230.293749999993)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 0.28 | 1.33 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-643497.783690105,-1062422.26509355,229.593749999993),(-643495.783690105,-1062420.26509355,230.293749999993)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 0.49 | 1.33 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642825.430821534,-1062726.18738855,232.134590757912),(-642824.330821534,-1062725.08738855,232.834590757912)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 739.3 | 739.53 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642825.880821534,-1062726.63738855,232.134590757912),(-642823.880821534,-1062724.63738855,232.834590757912)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 737.72 | 740.25 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642825.880821534,-1062726.63738855,232.134590757912),(-642823.880821534,-1062724.63738855,232.834590757912)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 737.72 | 740.25 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642830.079754886,-1062744.22886688,231.999130434822),(-642828.979754886,-1062743.12886688,232.699130434822)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 739.59 | 739.81 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642830.529754886,-1062744.67886688,231.999130434822),(-642828.529754886,-1062742.67886688,232.699130434822)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 738.13 | 740.48 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642830.529754886,-1062744.67886688,231.999130434822),(-642828.529754886,-1062742.67886688,232.699130434822)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 738.13 | 740.48 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642801.759605286,-1062717.82103927,232.362343076558),(-642800.659605286,-1062716.72103927,233.062343076558)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 761.71 | 761.96 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642802.209605286,-1062718.27103927,232.362343076558),(-642800.209605286,-1062716.27103927,233.062343076558)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 760.11 | 762.63 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642802.209605286,-1062718.27103927,232.362343076558),(-642800.209605286,-1062716.27103927,233.062343076558)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 760.11 | 762.63 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642799.279379287,-1062708.71958094,232.357045243993),(-642798.179379287,-1062707.61958094,233.057045243993)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 762.62 | 762.89 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642799.729379287,-1062709.16958094,232.357045243993),(-642797.729379287,-1062707.16958094,233.057045243993)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 760.95 | 763.58 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642799.729379287,-1062709.16958094,232.357045243993),(-642797.729379287,-1062707.16958094,233.057045243993)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 760.95 | 763.58 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642748.051974666,-1062729.96356399,232.359391812542),(-642746.951974666,-1062728.86356399,233.059391812542)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 798.28 | 798.41 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642748.501974666,-1062730.41356399,232.359391812542),(-642746.501974666,-1062728.41356399,233.059391812542)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 796.75 | 799.5 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642748.501974666,-1062730.41356399,232.359391812542),(-642746.501974666,-1062728.41356399,233.059391812542)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 796.75 | 799.5 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642746.328536914,-1062738.67359977,232.366352979393),(-642745.228536914,-1062737.57359977,233.066352979393)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 813.93 | 814.12 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642746.778536914,-1062739.12359977,232.366352979393),(-642744.778536914,-1062737.12359977,233.066352979393)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 805.09 | 815.16 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642746.778536914,-1062739.12359977,232.366352979393),(-642744.778536914,-1062737.12359977,233.066352979393)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 805.09 | 815.16 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642666.567236381,-1062725.89378616,231.502284088931),(-642665.467236381,-1062724.79378616,232.202284088931)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 868.92 | 869.12 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642667.017236381,-1062726.34378616,231.502284088931),(-642665.017236381,-1062724.34378616,232.202284088931)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 867.1 | 870.21 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642667.017236381,-1062726.34378616,231.502284088931),(-642665.017236381,-1062724.34378616,232.202284088931)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 867.1 | 870.21 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642744.133923954,-1062766.28879025,232.598658054717),(-642743.033923954,-1062765.18879025,233.298658054717)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 834.53 | 834.71 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642744.583923954,-1062766.73879025,232.598658054717),(-642742.583923954,-1062764.73879025,233.298658054717)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 832.87 | 835.71 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642744.583923954,-1062766.73879025,232.598658054717),(-642742.583923954,-1062764.73879025,233.298658054717)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 832.87 | 835.71 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-642756.095640357,-1062783.68800949,232.428843100226),(-642754.995640357,-1062782.58800949,233.128843100226)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 837.12 | 837.3 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-642756.545640357,-1062784.13800949,232.428843100226),(-642754.545640357,-1062782.13800949,233.128843100226)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 835.5 | 838.28 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-642756.545640357,-1062784.13800949,232.428843100226),(-642754.545640357,-1062782.13800949,233.128843100226)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 835.5 | 838.28 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-641711.340950313,-1063309.2325967,231.289092932095),(-641710.240950313,-1063308.1325967,231.989092932095)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 2005.92 | 2006.14 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-641711.790950313,-1063309.6825967,231.289092932095),(-641709.790950313,-1063307.6825967,231.989092932095)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 2004.31 | 2006.97 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-641711.790950313,-1063309.6825967,231.289092932095),(-641709.790950313,-1063307.6825967,231.989092932095)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 2004.31 | 2006.97 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-640639.899710836,-1063794.3173368,236.33),(-640638.799710836,-1063793.2173368,237.03)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 3181.89 | 3182.12 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-640640.349710836,-1063794.7673368,236.33),(-640638.349710836,-1063792.7673368,237.03)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3180.39 | 3182.78 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-640640.349710836,-1063794.7673368,236.33),(-640638.349710836,-1063792.7673368,237.03)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3180.39 | 3182.78 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-640615.24403205,-1063799.68575648,236.2),(-640614.14403205,-1063798.58575648,236.9)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 3206.93 | 3207.17 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-640615.69403205,-1063800.13575648,236.2),(-640613.69403205,-1063798.13575648,236.9)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3205.46 | 3207.8 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-640615.69403205,-1063800.13575648,236.2),(-640613.69403205,-1063798.13575648,236.9)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3205.46 | 3207.8 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-639488.387584225,-1063520.84704663,230.153913182821),(-639487.287584225,-1063519.74704663,230.853913182821)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 4380.29 | 4380.53 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-639488.837584225,-1063521.29704663,230.153913182821),(-639486.837584225,-1063519.29704663,230.853913182821)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4378.84 | 4381.12 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-639488.837584225,-1063521.29704663,230.153913182821),(-639486.837584225,-1063519.29704663,230.853913182821)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4378.84 | 4381.12 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-639490.270997062,-1063508.35992032,230.072512388033),(-639489.170997062,-1063507.25992032,230.772512388033)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 4380.26 | 4380.49 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-639490.720997062,-1063508.80992032,230.072512388033),(-639488.720997062,-1063506.80992032,230.772512388033)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4378.82 | 4381.08 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-639490.720997062,-1063508.80992032,230.072512388033),(-639488.720997062,-1063506.80992032,230.772512388033)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4378.82 | 4381.08 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-639441.06200286,-1063474.34430218,229.538286655344),(-639439.96200286,-1063473.24430218,230.238286655344)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 4432.77 | 4433 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-639441.512002859,-1063474.79430218,229.538286655344),(-639439.512002859,-1063472.79430218,230.238286655344)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4431.39 | 4433.55 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-639441.512002859,-1063474.79430218,229.538286655344),(-639439.512002859,-1063472.79430218,230.238286655344)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4431.39 | 4433.55 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-639430.77398425,-1063472.49764905,229.514793361628),(-639429.67398425,-1063471.39764905,230.214793361628)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 4442.97 | 4443.21 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-639431.22398425,-1063472.94764905,229.514793361628),(-639429.22398425,-1063470.94764905,230.214793361628)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4441.59 | 4443.75 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-639431.22398425,-1063472.94764905,229.514793361628),(-639429.22398425,-1063470.94764905,230.214793361628)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4441.59 | 4443.75 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-639548.446899436,-1063361.4389775,228.755880989157),(-639547.346899436,-1063360.3389775,229.455880989157)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 4347.54 | 4347.75 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-639548.896899436,-1063361.8889775,228.755880989157),(-639546.896899436,-1063359.8889775,229.455880989157)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4346.21 | 4348.31 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-639548.896899436,-1063361.8889775,228.755880989157),(-639546.896899436,-1063359.8889775,229.455880989157)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4346.21 | 4348.31 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
objekty na KV-šachta | 3.59798 | 2 | yes | ((-638911.576864071,-1063531.36122836,228.933167189921),(-638910.476864071,-1063530.26122836,229.633167189921)) | 9 | objekty na KV-šachta | Barva_9 | objekty na KV | 4960.3 | 4960.54 | šachta | 75ID21 | I1+S2+E1+Z1+M4+F1 | P10 | 191;191;191 | CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: komora; Stavební výrobek: plast; Specifikace: Komora kabelová ROMOLD KS 100.63/70.10; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 14.6935 | 2 | yes | ((-638912.026864071,-1063531.81122836,228.933167189921),(-638910.026864071,-1063529.81122836,229.633167189921)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4958.81 | 4961.19 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.30291 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 13.6 | 2 | yes | ((-638912.026864071,-1063531.81122836,228.933167189921),(-638910.026864071,-1063529.81122836,229.633167189921)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4958.81 | 4961.19 | výkop rýhy | 131836 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.8 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 10.55 | 1 | no | ((-642687.317453707,-1062835.70109838,232.360120256578),(-642682.267448599,-1062831.8771084,232.883875245393)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 919.77 | 925.71 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.05 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8.85004 | 1 | no | ((-642408.464138273,-1062981.7886655,230.937551724059),(-642403.80875389,-1062979.30081374,231.462629788687)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 1234.3 | 1239.3 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.875 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 12.25 | 1 | no | ((-641577.134075416,-1063374.28940842,230.584268344754),(-641570.645153912,-1063371.00649729,231.092119686938)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 2153.25 | 2160.25 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 1.225 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 1173.94 | 1 | no | ((-641197.207238373,-1063734.53978091,235.887131012933),(-640803.075015649,-1063549.88297643,239.058558245179)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 2573.17 | 3008.16 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 152.075 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8.85031 | 1 | no | ((-640737.378146492,-1063764.84184845,236.782218831568),(-640732.64880032,-1063762.55151335,237.333413335698)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3079.48 | 3084.47 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.875 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8.85004 | 1 | no | ((-640056.661991331,-1063700.59188704,232.857761592433),(-640051.88021707,-1063698.43797802,233.382860817466)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3780.57 | 3785.57 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.875 | objemová metoda | nerelevantni | 1
zemní práce-výkop rýhy | 8.85004 | 1 | no | ((-639750.438906716,-1063583.16212229,231.209609939294),(-639745.574911183,-1063581.28435517,231.734793807208)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4108.88 | 4113.9 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 0.875 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 633.816 | 1 | no | ((-639547.975502191,-1063530.98317092,228.093566384529),(-638910.987310412,-1063360.73262339,229.519489688895)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 4347.17 | 4960 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 24.6452 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 563.364 | 1 | no | ((-639547.975502191,-1063530.98317092,228.193566384529),(-638910.987310412,-1063360.73262339,229.569489688895)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 4347.17 | 4960 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 12.3226 | objemová metoda | CZ_M6 - Tloušťka: 0; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 1197.43 | 1 | no | ((-639547.975502191,-1063530.98317092,228.093566384529),(-638910.987310412,-1063360.73262339,229.919489688895)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4347.17 | 4960 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 123.226 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 986.075 | 1 | no | ((-639547.975502191,-1063530.98317092,228.243566384529),(-638910.987310412,-1063360.73262339,229.919489688895)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4347.17 | 4960 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 86.2583 | objemová metoda | nerelevantni | 1
