Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 2

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 404.ifc
Time: 2025-03-20T11:17:07
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 404
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcAnnotation: StringLine (42)
In: UnknownName
PredefinedType: USERDEFINED
Properties - CorridorFeaturelineRegionName: All; CreateFeatureLineDynamicLink: yes; FeatureLineEndCriteriaBeadStation: 0; FeatureLineStartCriteriaBeadStation: 0; ElevationPointsCount: 0; StyleName: Modrá __________; DisplayName: Automatická návrhová linie koridoru; FingerPrint: 0; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: no; ShowToolTip: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - ColorIndex: 6; Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: Barva_6; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 404; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Chráničky VRS; Označení elementu: kabel; Skupina elementů: kabelové vedení; Klasifikační systém: OTSKP; Označení položky: 75I911; Označení šablony vlastností: I1+S2+E1+Z1+M1+F1
CZ_S2 - Typ stavebního výrobku: chránička; Stavební výrobek: HDPE 40/33; Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_Z1 - Textura / barva: 255;0;255; Skupina přesnosti: P10
CZ_M1 - Způsob stanovení délky: Délka 3D křivky
CZ_F1 - Fáze: trvalý stav
Name | CorridorFeaturelineCode | CorridorFeaturelineSide | CorridorName | CurvesCount | Length2D | Length3D | MaxElevation | MaxGrade | MinElevation | MinGrade | PIPointsCount = PointsCount | Name | Bounds | Layer | Staničení od | Staničení do | Specifikace | Délka
úsek 2-KabelGray | KabelGray | Levá | úsek 2 | 0 | 56.7592 | 56.7621 | 232.485 | 0.0172447 | 232.242 | 7.90358e-07 | 43 | úsek 2-KabelGray | ((-642798.734319817,-1062729.67172476,232.241631513621),(-642747.485958821,-1062708.18623989,232.485364770652)) | kabelové vedení-kabel-Š | 762.28 | 798.18 | barva šedá | 56.757
úsek 2-KabelGreen | KabelGreen | Pravá | úsek 2 | 0 | 56.7848 | 56.7877 | 232.485 | 0.0171569 | 232.242 | 7.89033e-07 | 43 | úsek 2-KabelGreen | ((-642798.752949834,-1062729.75190595,232.241631513621),(-642747.479253392,-1062708.2640393,232.485364770652)) | kabelové vedení-kabel-G | 762.27 | 798.25 | barva zelená | 56.7859
úsek 2-KabelRed | KabelRed | Střed | úsek 2 | 0 | 277.195 | 277.203 | 232.485 | 0.0240111 | 231.135 | 7.89695e-07 | 167 | úsek 2-KabelRed | ((-642991.819066592,-1062729.71181535,231.134944879351),(-642747.482606106,-1062621.30943762,232.485364770652)) | kabelové vedení-kabel-R | 543.08 | 798.21 | barva červená | 277.207
úsek 1-KabelGray | KabelGray | Levá | úsek 1 | 1 | 775.311 | 775.336 | 232.268 | 0.21504 | 229.474 | 0 | 400 | úsek 1-KabelGray | ((-643496.767025207,-1062728.8810762,229.473749999888),(-642798.059378282,-1062421.22873037,232.26837263722)) | kabelové vedení-kabel-Š | 0 | 761.36 | barva šedá | 775.336
úsek 1-KabelGreen | KabelGreen | Pravá | úsek 1 | 1 | 775.555 | 775.579 | 232.268 | 0.21504 | 229.474 | 0.00051814 | 400 | úsek 1-KabelGreen | ((-643496.800355003,-1062728.96105783,229.473749999888),(-642797.978712558,-1062421.30145673,232.26837263722)) | kabelové vedení-kabel-G | 0 | 761.39 | barva zelená | 775.579
úsek 1-KabelRed | KabelRed | Střed | úsek 1 | 1 | 775.433 | 775.457 | 232.268 | 0.21504 | 229.474 | 0.000521524 | 400 | úsek 1-KabelRed | ((-643496.783690105,-1062728.92106702,229.473749999888),(-642798.01904542,-1062421.26509355,232.26837263722)) | kabelové vedení-kabel-R | 0 | 761.37 | barva červená | 775.457
úsek 3-KabelGray | KabelGray | Levá | úsek 3 | 0 | 120.566 | 120.577 | 232.509 | 0.0261643 | 231.282 | 0 | 150 | úsek 3-KabelGray | ((-642757.411755297,-1062765.76955511,231.282284088932),(-642666.011498194,-1062725.38337244,232.509136019549)) | kabelové vedení-kabel-Š | 868.69 | 834.32 | barva šedá | 120.574
úsek 3-KabelGreen | KabelGreen | Pravá | úsek 3 | 0 | 120.744 | 120.754 | 232.509 | 0.0260973 | 231.282 | 0.00258061 | 150 | úsek 3-KabelGreen | ((-642757.491978393,-1062765.82573266,231.282284088932),(-642666.022974567,-1062725.30419989,232.509136019549)) | kabelové vedení-kabel-G | 868.62 | 834.31 | barva zelená | 120.75
úsek 3-KabelRed | KabelRed | Střed | úsek 3 | 0 | 120.655 | 120.666 | 232.509 | 0.0261308 | 231.282 | 0.00258062 | 150 | úsek 3-KabelRed | ((-642757.451866845,-1062765.79764389,231.282284088932),(-642666.017236381,-1062725.34378616,232.509136019549)) | kabelové vedení-kabel-R | 868.65 | 834.31 | barva červená | 120.675
úsek 4-KabelGray | KabelGray | Levá | úsek 4 | 0 | 2432.86 | 2432.98 | 238.119 | 0.218719 | 230.325 | 0.00000300755 | 825 | úsek 4-KabelGray | ((-642829.476353584,-1063793.67572552,230.32450084202),(-640639.325464135,-1062743.54501677,238.118558245245)) | kabelové vedení-kabel-Š | 739.32 | 3181.59 | barva šedá | 2432.98
úsek 4-KabelGreen | KabelGreen | Pravá | úsek 4 | 0 | 2432.87 | 2432.99 | 238.119 | 0.222129 | 230.325 | 0.00000300755 | 825 | úsek 4-KabelGreen | ((-642829.508800775,-1063793.75351213,230.32450084202),(-640639.344152201,-1062743.61814118,238.118558245245)) | kabelové vedení-kabel-G | 739.31 | 3181.59 | barva zelená | 2432.99
úsek 4-KabelRed | KabelRed | Střed | úsek 4 | 0 | 2432.87 | 2433.04 | 238.079 | 0.407292 | 230.325 | 0.00000300755 | 825 | úsek 4-KabelRed | ((-642829.492577179,-1063793.71461882,230.32450084202),(-640639.334808168,-1062743.58157897,238.078558245208)) | kabelové vedení-kabel-R | 739.32 | 3181.59 | barva červená | 2433.04
úsek 5-KabelGray | KabelGray | Levá | úsek 5 | 0 | 1175.4 | 1175.43 | 236.082 | 0.117297 | 230.039 | 0.00396323 | 376 | úsek 5-KabelGray | ((-640614.672257093,-1063812.57120066,230.038810983766),(-639487.836694718,-1063520.19353205,236.081680899952)) | kabelové vedení-kabel-Š | 3206.63 | 4380 | barva šedá | 1175.43
úsek 5-KabelGreen | KabelGreen | Pravá | úsek 5 | 0 | 1175.43 | 1175.45 | 236.082 | 0.117297 | 230.039 | 0.00396323 | 376 | úsek 5-KabelGreen | ((-640614.687589129,-1063812.65120136,230.038810983766),(-639487.82471872,-1063520.27263057,236.081680899952)) | kabelové vedení-kabel-G | 3206.63 | 4380 | barva zelená | 1175.45
úsek 5-KabelRed | KabelRed | Střed | úsek 5 | 0 | 1175.42 | 1175.46 | 236.082 | 0.217099 | 230.039 | 0.0046961 | 376 | úsek 5-KabelRed | ((-640614.679923111,-1063812.61120101,230.038810983766),(-639487.830706719,-1063520.23308131,236.081680899952)) | kabelové vedení-kabel-R | 3206.63 | 4380 | barva červená | 1175.46
úsek 6-KabelGray | KabelGray | Levá | úsek 6 | 0 | 69.8675 | 69.8741 | 229.958 | 0.0313972 | 229.352 | 0.00133333 | 126 | úsek 6-KabelGray | ((-639489.707724477,-1063507.83417099,229.352350214496),(-639440.388895886,-1063473.77445209,229.957741126884)) | kabelové vedení-kabel-Š | 4379.96 | 4432.5 | barva šedá | 69.8741
úsek 6-KabelGreen | KabelGreen | Pravá | úsek 6 | 0 | 69.9829 | 69.9895 | 229.958 | 0.0309597 | 229.352 | 0.00133212 | 126 | úsek 6-KabelGreen | ((-639489.696243076,-1063507.91334281,229.352350214496),(-639440.308895737,-1063473.77325733,229.957741126884)) | kabelové vedení-kabel-G | 4379.96 | 4432.58 | barva zelená | 69.9895
úsek 6-KabelRed | KabelRed | Střed | úsek 6 | 0 | 69.9252 | 69.9318 | 229.958 | 0.0311769 | 229.352 | 0.00133332 | 126 | úsek 6-KabelRed | ((-639489.701983776,-1063507.8737569,229.352350214496),(-639440.348895811,-1063473.77385471,229.957741126884)) | kabelové vedení-kabel-R | 4379.96 | 4432.54 | barva červená | 69.9318
úsek 7-KabelGray | KabelGray | Levá | úsek 7 | 0 | 704.159 | 704.17 | 229.499 | 0.0238833 | 228.174 | 0 | 295 | úsek 7-KabelGray | ((-639547.878933092,-1063530.7732139,228.173566384707),(-638911.01581108,-1063360.85323942,229.49948968878)) | kabelové vedení-kabel-Š | 4347.28 | 4960 | barva šedá | 704.2
úsek 7-KabelGreen | KabelGreen | Pravá | úsek 7 | 0 | 704.179 | 704.19 | 229.499 | 0.0222943 | 228.174 | 0 | 295 | úsek 7-KabelGreen | ((-639547.91486578,-1063530.85136583,228.173566384707),(-638911.032907126,-1063360.92471558,229.49948968878)) | kabelové vedení-kabel-G | 4347.24 | 4960 | barva zelená | 704.2
úsek 7-KabelRed | KabelRed | Střed | úsek 7 | 0 | 704.169 | 704.18 | 229.499 | 0.0230614 | 228.174 | 0 | 295 | úsek 7-KabelRed | ((-639547.896899436,-1063530.81228987,228.173566384707),(-638911.024359103,-1063360.8889775,229.49948968878)) | kabelové vedení-kabel-R | 4347.26 | 4960 | barva červená | 704.2
překopy-KabelGray-1 | KabelGray | Levá | překopy | 0 | 18.4687 | 18.4692 | 231.974 | 0.00714786 | 231.842 | 0.00714786 | 2 | překopy-KabelGray-1 | ((-642829.453849514,-1062743.59158737,231.842448981944),(-642824.832787536,-1062725.71029955,231.974460960366)) | kabelové vedení-kabel-Š | 739.06 | 739.36 | barva šedá | 18.4692
překopy-KabelGray-2 | KabelGray | Levá | překopy | 0 | 9.29427 | 9.29428 | 232.207 | 0.00108527 | 232.197 | 0.00108527 | 2 | překopy-KabelGray-2 | ((-642801.233277638,-1062717.17983561,232.196631585713),(-642798.782001193,-1062708.2146421,232.206718391273)) | kabelové vedení-kabel-Š | 761.33 | 762.22 | barva šedá | 9.29428
překopy-KabelGray-3 | KabelGray | Levá | překopy | 0 | 8.72054 | 8.72054 | 232.207 | 0.000626919 | 232.202 | 0.000626919 | 2 | překopy-KabelGray-3 | ((-642747.443361109,-1062738.05320385,232.20171311032),(-642745.757027723,-1062729.49726876,232.207180178724)) | kabelové vedení-kabel-Š | 798.23 | 813.67 | barva šedá | 8.72054
překopy-KabelGray-4 | KabelGray | Levá | překopy | 0 | 20.9984 | 20.9991 | 232.438 | 0.00810132 | 232.268 | 0.00810132 | 3 | překopy-KabelGray-4 | ((-642755.47943174,-1062783.11686989,232.268267427105),(-642743.57309387,-1062765.82032439,232.438381892163)) | kabelové vedení-kabel-Š | 834.35 | 836.93 | barva šedá | 20.9991
překopy-KabelGray-5 | KabelGray | Levá | překopy | 0 | 25.2321 | 25.2324 | 236.21 | 0.00500085 | 236.084 | 0.0050002 | 6 | překopy-KabelGray-5 | ((-640639.325464135,-1063799.04008144,236.083830873016),(-640614.672257093,-1063793.67572552,236.209999999963)) | kabelové vedení-kabel-Š | 3181.59 | 3206.63 | barva šedá | 25.2324
překopy-KabelGray-6 | KabelGray | Levá | překopy | 0 | 12.4999 | 12.5002 | 229.994 | 0.00648406 | 229.913 | 0.00648406 | 2 | překopy-KabelGray-6 | ((-639489.741496487,-1063520.23906931,229.912760654464),(-639487.870255978,-1063507.87998629,229.99381098384)) | kabelové vedení-kabel-Š | 4379.96 | 4379.92 | barva šedá | 12.5002
překopy-KabelGray-7 | KabelGray | Levá | překopy | 0 | 10.3214 | 10.3214 | 229.379 | 0.00240112 | 229.354 | 0.00240112 | 2 | překopy-KabelGray-7 | ((-639440.4476115,-1063473.73448034,229.354216846637),(-639430.287668417,-1063471.91614397,229.378999669105)) | kabelové vedení-kabel-Š | 4432.54 | 4442.61 | barva šedá | 10.3214
překopy-KabelGreen-8 | KabelGreen | Pravá | překopy | 0 | 18.4687 | 18.4692 | 231.974 | 0.00714786 | 231.842 | 0.00714786 | 2 | překopy-KabelGreen-8 | ((-642829.531304845,-1062743.57157058,231.842448981944),(-642824.910242868,-1062725.69028277,231.974460960366)) | kabelové vedení-kabel-G | 738.97 | 739.28 | barva zelená | 18.4692
překopy-KabelGreen-9 | KabelGreen | Pravá | překopy | 0 | 9.29427 | 9.29428 | 232.207 | 0.00108527 | 232.197 | 0.00108527 | 2 | překopy-KabelGreen-9 | ((-642801.156110146,-1062717.20093486,232.196631585713),(-642798.704833702,-1062708.23574135,232.206718391273)) | kabelové vedení-kabel-G | 761.42 | 762.31 | barva zelená | 9.29428
překopy-KabelGreen-10 | KabelGreen | Pravá | překopy | 0 | 8.72054 | 8.72054 | 232.207 | 0.000626919 | 232.202 | 0.000626919 | 2 | překopy-KabelGreen-10 | ((-642747.521851104,-1062738.06867385,232.20171311032),(-642745.835517718,-1062729.51273876,232.207180178724)) | kabelové vedení-kabel-G | 798.2 | 813.62 | barva zelená | 8.72054
překopy-KabelGreen-11 | KabelGreen | Pravá | překopy | 0 | 20.9984 | 20.9991 | 232.438 | 0.00810132 | 232.268 | 0.00810132 | 3 | překopy-KabelGreen-11 | ((-642755.545328469,-1062783.07150888,232.268267427105),(-642743.6389906,-1062765.77496338,232.438381892163)) | kabelové vedení-kabel-G | 834.27 | 836.85 | barva zelená | 20.9991
překopy-KabelGreen-12 | KabelGreen | Pravá | překopy | 0 | 25.2355 | 25.2359 | 236.21 | 0.0049998 | 236.084 | 0.00499915 | 6 | překopy-KabelGreen-12 | ((-640639.344152201,-1063799.1185985,236.083830873016),(-640614.687589129,-1063793.75351213,236.209999999963)) | kabelové vedení-kabel-G | 3181.59 | 3206.63 | barva zelená | 25.2359
překopy-KabelGreen-13 | KabelGreen | Pravá | překopy | 0 | 12.4999 | 12.5002 | 229.994 | 0.00648406 | 229.913 | 0.00648406 | 2 | překopy-KabelGreen-13 | ((-639489.66239797,-1063520.22709331,229.912760654464),(-639487.791157461,-1063507.86801029,229.99381098384)) | kabelové vedení-kabel-G | 4380.04 | 4380 | barva zelená | 12.5002
překopy-KabelGreen-14 | KabelGreen | Pravá | překopy | 0 | 10.3214 | 10.3214 | 229.379 | 0.00240112 | 229.354 | 0.00240112 | 2 | překopy-KabelGreen-14 | ((-639440.433517748,-1063473.81322909,229.354216846637),(-639430.273574665,-1063471.99489272,229.378999669105)) | kabelové vedení-kabel-G | 4432.54 | 4442.62 | barva zelená | 10.3214
překopy-KabelRed-15 | KabelRed | Střed | překopy | 0 | 18.4687 | 18.4692 | 231.934 | 0.00714786 | 231.802 | 0.00714786 | 2 | překopy-KabelRed-15 | ((-642829.492577179,-1062743.58157897,231.802448981907),(-642824.871515202,-1062725.70029116,231.934460960329)) | kabelové vedení-kabel-R | 739.02 | 739.32 | barva červená | 18.4692
překopy-KabelRed-16 | KabelRed | Střed | překopy | 0 | 9.29427 | 9.29428 | 232.167 | 0.00108527 | 232.157 | 0.00108527 | 2 | překopy-KabelRed-16 | ((-642801.194693892,-1062717.19038524,232.156631585676),(-642798.743417447,-1062708.22519172,232.166718391236)) | kabelové vedení-kabel-R | 761.37 | 762.27 | barva červená | 9.29428
překopy-KabelRed-17 | KabelRed | Střed | překopy | 0 | 8.72054 | 8.72054 | 232.167 | 0.000626919 | 232.162 | 0.000626919 | 2 | překopy-KabelRed-17 | ((-642747.482606106,-1062738.06093885,232.161713110283),(-642745.79627272,-1062729.50500376,232.167180178687)) | kabelové vedení-kabel-R | 798.21 | 813.64 | barva červená | 8.72054
překopy-KabelRed-18 | KabelRed | Střed | překopy | 0 | 20.9984 | 20.9991 | 232.398 | 0.00810132 | 232.228 | 0.00810132 | 3 | překopy-KabelRed-18 | ((-642755.512380105,-1062783.09418939,232.228267427068),(-642743.606042235,-1062765.79764389,232.398381892126)) | kabelové vedení-kabel-R | 834.31 | 836.89 | barva červená | 20.9991
překopy-KabelRed-19 | KabelRed | Střed | překopy | 0 | 25.2338 | 25.2341 | 236.21 | 0.005 | 236.084 | 0.005 | 6 | překopy-KabelRed-19 | ((-640639.334808168,-1063799.07933997,236.083830873016),(-640614.679923111,-1063793.71461882,236.209999999963)) | kabelové vedení-kabel-R | 3181.59 | 3206.63 | barva červená | 25.2341
překopy-KabelRed-20 | KabelRed | Střed | překopy | 0 | 12.4999 | 12.5002 | 229.954 | 0.00648406 | 229.873 | 0.00648406 | 2 | překopy-KabelRed-20 | ((-639489.701947228,-1063520.23308131,229.872760654427),(-639487.830706719,-1063507.87399829,229.953810983803)) | kabelové vedení-kabel-R | 4380 | 4379.96 | barva červená | 12.5002
překopy-KabelRed-21 | KabelRed | Střed | překopy | 0 | 10.3214 | 10.3214 | 229.339 | 0.00240112 | 229.314 | 0.00240112 | 2 | překopy-KabelRed-21 | ((-639440.440564624,-1063473.77385471,229.3142168466),(-639430.280621541,-1063471.95551835,229.338999669068)) | kabelové vedení-kabel-R | 4432.54 | 4442.62 | barva červená | 10.3214

# IfcBuiltElement (235)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: trvalý stav
CZ_I1 - Označení stavebního objektu: SO 404; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Chráničky VRS; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Skupina elementů | Staničení od | Staničení do | Označení elementu | Označení položky | Označení šablony vlastností | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Klasifikace zemin / hornin = Další specifikace | Třída těžitelnosti
kabelové vedení-podkladní vrstva | 697.736 | 1 | no | ((-643496.856599034,-1062729.09602683,229.393749999997),(-642797.960718919,-1062421.10600462,232.288372637145)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 0 | 765.81 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 27.1282 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 620.159 | 1 | no | ((-643496.856599034,-1062729.09602683,229.493749999997),(-642797.960718919,-1062421.10600462,232.338372637145)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 0 | 765.81 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 13.5641 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 1318.36 | 1 | no | ((-643496.856599034,-1062729.09602683,229.393749999997),(-642797.960718919,-1062421.10600462,232.688372637145)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 0 | 765.81 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 135.641 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 1085.62 | 1 | no | ((-643496.856599034,-1062729.09602683,229.543749999997),(-642797.960718919,-1062421.10600462,232.688372637145)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 0 | 765.81 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 94.9487 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 198.455 | 1 | no | ((-642991.99411711,-1062708.39558783,231.054944879351),(-642798.703568814,-1062621.25387239,232.261631513531)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 542.9 | 762.28 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 7.71481 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 176.377 | 1 | no | ((-642991.99411711,-1062708.39558783,231.154944879351),(-642798.703568814,-1062621.25387239,232.311631513531)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 542.9 | 762.28 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 3.8574 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 375.073 | 1 | no | ((-642991.99411711,-1062708.39558783,231.054944879351),(-642798.703568814,-1062621.25387239,232.661631513531)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 542.9 | 762.28 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 38.574 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 308.841 | 1 | no | ((-642991.99411711,-1062708.39558783,231.204944879351),(-642798.703568814,-1062621.25387239,232.661631513531)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 542.9 | 762.28 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 27.0018 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 51.1196 | 1 | no | ((-642798.783293671,-1062729.88234143,232.161631513621),(-642747.461202316,-1062708.05478886,232.50536289352)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 762.26 | 798.37 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.98471 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 45.408 | 1 | no | ((-642798.783293671,-1062729.88234143,232.261631513621),(-642747.461202316,-1062708.05478886,232.55536289352)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 762.26 | 798.37 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.992357 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 96.813 | 1 | no | ((-642798.783293671,-1062729.88234143,232.161631513621),(-642747.461202316,-1062708.05478886,232.90536289352)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 762.26 | 798.37 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 9.92356 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 79.678 | 1 | no | ((-642798.783293671,-1062729.88234143,232.311631513621),(-642747.461202316,-1062708.05478886,232.90536289352)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 762.26 | 798.37 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 6.94649 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 108.553 | 1 | no | ((-642757.524657793,-1062765.92053228,231.202284539718),(-642665.992343582,-1062725.17062127,232.529136019549)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 804.91 | 868.8 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 4.21732 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 96.4537 | 1 | no | ((-642757.524657793,-1062765.92053228,231.302284539718),(-642665.992343582,-1062725.17062127,232.579136019549)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 804.91 | 868.8 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 2.10866 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 205.352 | 1 | no | ((-642757.524657793,-1062765.92053228,231.202284539718),(-642665.992343582,-1062725.17062127,232.929136019549)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 804.91 | 868.8 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 21.0866 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 169.053 | 1 | no | ((-642757.524657793,-1062765.92053228,231.352284539718),(-642665.992343582,-1062725.17062127,232.929136019549)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 804.91 | 868.8 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 14.7606 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 63.0073 | 1 | no | ((-639489.727099342,-1063508.04694526,229.272350214303),(-639440.173895485,-1063473.77124117,229.977741126818)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 4379.96 | 4432.71 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 2.44738 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 55.9798 | 1 | no | ((-639489.727099342,-1063508.04694526,229.372350214303),(-639440.173895485,-1063473.77124117,230.027741126818)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 4379.96 | 4432.71 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 1.22369 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 119.227 | 1 | no | ((-639489.727099342,-1063508.04694526,229.272350214303),(-639440.173895485,-1063473.77124117,230.377741126818)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4379.96 | 4432.71 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 12.2369 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 98.1449 | 1 | no | ((-639489.727099342,-1063508.04694526,229.422350214303),(-639440.173895485,-1063473.77124117,230.377741126818)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4379.96 | 4432.71 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 8.56584 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 1.97483 | 1 | no | ((-640056.62085812,-1063700.48717644,232.857761592433),(-640051.921350281,-1063698.54268861,233.007860817466)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 3780.57 | 3785.57 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 5
2 x zemní práce-zásyp rýhy | 7.37327 | 1 | no | ((-640056.661991331,-1063700.59188704,232.857761592433),(-640051.88021707,-1063698.43797802,233.082860817466)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3780.57 | 3785.57 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.289725 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 6.71004 | 1 | no | ((-640056.661991331,-1063700.59188704,233.057761592433),(-640051.88021707,-1063698.43797802,233.382860817466)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3780.57 | 3785.57 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.525 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 1.97483 | 1 | no | ((-639750.403623202,-1063583.05529849,231.209609939294),(-639745.609526363,-1063581.3913974,231.359793807208)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 4108.88 | 4113.9 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 5
2 x zemní práce-zásyp rýhy | 7.37327 | 1 | no | ((-639750.438906716,-1063583.16212229,231.209609939294),(-639745.574911183,-1063581.28435517,231.434793807208)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4108.88 | 4113.9 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.289725 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 6.71004 | 1 | no | ((-639750.438906716,-1063583.16212229,231.409609939294),(-639745.574911183,-1063581.28435517,231.734793807208)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4108.88 | 4113.9 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.525 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 2.36501 | 1 | no | ((-642687.250522856,-1062835.60999373,232.360120256578),(-642682.333450051,-1062831.96753246,232.508875245393)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 919.77 | 925.71 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 5
2 x zemní práce-zásyp rýhy | 8.82472 | 1 | no | ((-642687.317453707,-1062835.70109838,232.360120256578),(-642682.267448599,-1062831.8771084,232.583875245394)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 919.77 | 925.71 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.34767 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 8.01003 | 1 | no | ((-642687.317453707,-1062835.70109838,232.560120256578),(-642682.267448599,-1062831.8771084,232.883875245393)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 919.77 | 925.71 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.63 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 1.97483 | 1 | no | ((-642408.415254307,-1062981.68734123,230.937551724059),(-642403.857637856,-1062979.40213801,231.087629788687)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 1234.3 | 1239.3 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 5
2 x zemní práce-zásyp rýhy | 7.37327 | 1 | no | ((-642408.464138273,-1062981.7886655,230.937551724059),(-642403.80875389,-1062979.30081374,231.162629788687)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 1234.3 | 1239.3 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.289725 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 6.71004 | 1 | no | ((-642408.464138273,-1062981.7886655,231.137551724059),(-642403.80875389,-1062979.30081374,231.462629788687)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 1234.3 | 1239.3 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.525 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 2.75518 | 1 | no | ((-641577.086409491,-1063374.18750548,230.584268344754),(-641570.692819837,-1063371.10840023,230.717119686938)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 2153.25 | 2160.25 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 5
2 x zemní práce-zásyp rýhy | 10.2762 | 1 | no | ((-641577.134075416,-1063374.28940842,230.584268344754),(-641570.645153912,-1063371.00649729,230.792119686938)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 2153.25 | 2160.25 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.405615 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 9.31 | 1 | no | ((-641577.134075416,-1063374.28940842,230.784268344754),(-641570.645153912,-1063371.00649729,231.092119686938)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 2153.25 | 2160.25 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.735 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 169.756 | 1 | no | ((-641197.156669275,-1063734.43409876,235.887131012933),(-640803.11358422,-1063549.9834703,238.183558245179)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 2573.18 | 3008.16 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 434.98
2 x zemní práce-zásyp rýhy | 631.517 | 1 | no | ((-641197.207238373,-1063734.53978091,235.887131012933),(-640803.075015649,-1063549.88297643,238.258558245179)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 2573.17 | 3008.16 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 25.206 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 999.804 | 1 | no | ((-641197.207238373,-1063734.53978091,236.087131012933),(-640803.075015649,-1063549.88297643,239.058558245179)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 2573.17 | 3008.16 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 121.625 | objemová metoda | nerelevantni | 1
2 x kabelové vedení-chránička | 1.97491 | 1 | no | ((-640737.302718578,-1063764.73702246,236.782218831568),(-640732.68963856,-1063762.63498119,236.958413335698)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 3079.52 | 3084.47 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 5
2 x zemní práce-zásyp rýhy | 7.3736 | 1 | no | ((-640737.378146492,-1063764.84184845,236.782218831568),(-640732.64880032,-1063762.55151335,237.033413335698)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3079.48 | 3084.47 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.289725 | objemová metoda | nerelevantni | 1
2 x zemní práce-zásyp rýhy | 6.71031 | 1 | no | ((-640737.378146492,-1063764.84184845,236.982218831568),(-640732.64880032,-1063762.55151335,237.333413335698)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3079.48 | 3084.47 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 0.525 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 8.29212 | 1 | no | ((-639440.471394707,-1063473.94611761,229.244216846473),(-639430.249791457,-1063471.78325545,229.318999668973)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 4432.53 | 4442.63 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.180624 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 19.4971 | 1 | no | ((-639440.471394707,-1063473.94611761,229.244216846473),(-639430.249791457,-1063471.78325545,229.843999668973)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4432.53 | 4442.63 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.07718 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 14.1614 | 1 | no | ((-639440.471394707,-1063473.94611761,229.494216846473),(-639430.249791457,-1063471.78325545,229.843999668973)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4432.53 | 4442.63 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.17406 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 20.3661 | 1 | no | ((-642829.734625089,-1062743.64413143,231.732448981669),(-642824.629467292,-1062725.63773871,231.914460960425)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 738.76 | 739.56 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.461719 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 7.23016 | 1 | no | ((-642829.553089157,-1062743.59721709,231.782448981669),(-642824.811003224,-1062725.68465304,232.039460960425)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 738.95 | 739.38 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 18
trubní vedení-obetonování | 32.5238 | 1 | no | ((-642829.734625089,-1062743.64413143,231.782448981669),(-642824.629467292,-1062725.63773871,232.114460960425)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 738.76 | 739.56 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.62423 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 40.2833 | 1 | no | ((-642829.734625089,-1062743.64413143,231.732448981669),(-642824.629467292,-1062725.63773871,232.439460960425)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 738.76 | 739.56 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 5.30977 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 30.7989 | 1 | no | ((-642829.734625089,-1062743.64413143,231.982448981669),(-642824.629467292,-1062725.63773871,232.439460960425)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 738.76 | 739.56 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 3.00117 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 10.2737 | 1 | no | ((-642801.435842301,-1062717.25632039,232.086631585448),(-642798.502269038,-1062708.15925657,232.146718390986)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 761.1 | 762.55 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.232357 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 3.65036 | 1 | no | ((-642801.254980994,-1062717.20686902,232.136631585448),(-642798.683130345,-1062708.20870793,232.271718390986)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 761.31 | 762.34 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 9
trubní vedení-obetonování | 16.4545 | 1 | no | ((-642801.435842301,-1062717.25632039,232.136631585448),(-642798.502269038,-1062708.15925657,232.346718390986)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 761.1 | 762.55 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.817384 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 20.5577 | 1 | no | ((-642801.435842301,-1062717.25632039,232.086631585448),(-642798.502269038,-1062708.15925657,232.671718390986)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 761.1 | 762.55 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.6721 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 15.6606 | 1 | no | ((-642801.435842301,-1062717.25632039,232.336631585448),(-642798.502269038,-1062708.15925657,232.671718390986)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 761.1 | 762.55 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.51032 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 9.64259 | 1 | no | ((-642747.727887338,-1062738.1092826,232.091713109954),(-642745.550991489,-1062729.45666001,232.147180178555)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 798.13 | 813.79 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.218013 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 3.4265 | 1 | no | ((-642747.543926414,-1062738.07302479,232.141713109954),(-642745.734952412,-1062729.49291782,232.272180178555)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 798.19 | 813.68 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 9
trubní vedení-obetonování | 15.4496 | 1 | no | ((-642747.727887338,-1062738.1092826,232.141713109954),(-642745.550991489,-1062729.45666001,232.347180178555)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 798.13 | 813.79 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.766927 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 19.3242 | 1 | no | ((-642747.727887338,-1062738.1092826,232.091713109954),(-642745.550991489,-1062729.45666001,232.672180178555)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 798.13 | 813.79 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.50715 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 14.7139 | 1 | no | ((-642747.727887338,-1062738.1092826,232.341713109954),(-642745.550991489,-1062729.45666001,232.672180178555)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 798.13 | 813.79 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.41709 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 23.1489 | 1 | no | ((-642755.718307385,-1062783.23594253,232.15826742705),(-642743.400114954,-1062765.65589074,232.378381892026)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 834.06 | 837.13 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.524959 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 8.21721 | 1 | no | ((-642755.563861925,-1062783.12962767,232.20826742705),(-642743.554560415,-1062765.7622056,232.503381892026)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 834.25 | 836.95 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 20
trubní vedení-obetonování | 36.9546 | 1 | no | ((-642755.718307385,-1062783.23594253,232.20826742705),(-642743.400114954,-1062765.65589074,232.578381892026)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 834.06 | 837.13 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.8467 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 45.7222 | 1 | no | ((-642755.718307385,-1062783.23594253,232.15826742705),(-642743.400114954,-1062765.65589074,232.903381892026)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 834.06 | 837.13 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 6.03703 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 34.973 | 1 | no | ((-642755.718307385,-1062783.23594253,232.40826742705),(-642743.400114954,-1062765.65589074,232.903381892026)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 834.06 | 837.13 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 3.41223 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 13.8002 | 1 | no | ((-639489.949130095,-1063520.27050631,229.802760654483),(-639487.583523852,-1063507.8365733,229.933810983767)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 4379.71 | 4380.25 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.312498 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 4.9012 | 1 | no | ((-639489.763742945,-1063520.24243756,229.852760654483),(-639487.768911002,-1063507.86464205,230.058810983767)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 4379.9 | 4380.06 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 13
trubní vedení-obetonování | 22.0694 | 1 | no | ((-639489.949130095,-1063520.27050631,229.852760654483),(-639487.583523852,-1063507.8365733,230.133810983767)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 4379.71 | 4380.25 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.09931 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 27.4501 | 1 | no | ((-639489.949130095,-1063520.27050631,229.802760654483),(-639487.583523852,-1063507.8365733,230.458810983767)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4379.71 | 4380.25 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 3.59373 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 20.9502 | 1 | no | ((-639489.949130095,-1063520.27050631,230.052760654483),(-639487.583523852,-1063507.8365733,230.458810983767)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4379.71 | 4380.25 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 2.03124 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 11.4035 | 1 | no | ((-639440.4846076,-1063474.01994457,229.244216846473),(-639430.236578565,-1063471.70942849,229.318999668973)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 4432.53 | 4442.63 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.258034 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 4.05112 | 1 | no | ((-639440.451575368,-1063473.83537718,229.294216846473),(-639430.269610797,-1063471.89399588,229.443999668973)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 4432.54 | 4442.62 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11
trubní vedení-obetonování | 18.2535 | 1 | no | ((-639440.4846076,-1063474.01994457,229.294216846473),(-639430.236578565,-1063471.70942849,229.518999668973)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 4432.53 | 4442.63 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 0.907713 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 22.766 | 1 | no | ((-639440.4846076,-1063474.01994457,229.244216846473),(-639430.236578565,-1063471.70942849,229.843999668973)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 4432.53 | 4442.63 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 2.9674 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 17.3553 | 1 | no | ((-639440.4846076,-1063474.01994457,229.494216846473),(-639430.236578565,-1063471.70942849,229.843999668973)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 4432.53 | 4442.63 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.67722 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 151.269 | 1 | no | ((-642829.56355541,-1062832.15842771,231.807448981669),(-642687.109224394,-1062743.42161932,232.562280761579)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 739.29 | 919.77 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 5.87991 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 134.434 | 1 | no | ((-642829.56355541,-1062832.15842771,231.907448981669),(-642687.109224394,-1062743.42161932,232.612280761579)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 739.29 | 919.77 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 2.93996 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 285.949 | 1 | no | ((-642829.56355541,-1062832.15842771,231.807448981669),(-642687.109224394,-1062743.42161932,232.962280761579)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 739.29 | 919.77 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 29.3996 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 235.444 | 1 | no | ((-642829.56355541,-1062832.15842771,231.957448981669),(-642687.109224394,-1062743.42161932,232.962280761579)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 739.29 | 919.77 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 20.5797 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 179.172 | 1 | no | ((-642682.472786452,-1062931.38386528,231.544362823376),(-642508.285335547,-1062835.41766168,232.485120256578)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 925.71 | 1123.3 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 6.965 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 159.237 | 1 | no | ((-642682.472786452,-1062931.38386528,231.644362823376),(-642508.285335547,-1062835.41766168,232.535120256578)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 925.71 | 1123.3 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 3.4825 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 338.652 | 1 | no | ((-642682.472786452,-1062931.38386528,231.544362823376),(-642508.285335547,-1062835.41766168,232.885120256578)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 925.71 | 1123.3 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 34.825 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 278.847 | 1 | no | ((-642682.472786452,-1062931.38386528,231.694362823376),(-642508.285335547,-1062835.41766168,232.885120256578)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 925.71 | 1123.3 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 24.3775 | objemová metoda | nerelevantni | 1
odvodnění-podkladní beton | 13.2502 | 1 | no | ((-642508.470008306,-1062936.66570447,231.409175468269),(-642497.444823996,-1062931.0010847,231.519362823376)) | 9 | odvodnění-podkladní beton | Barva_9 | odvodnění | 1123.3 | 1135.3 | podkladní beton | 451311 | I1+S1+E1+Z1+M3+F1 | P10 | 191;191;191 | 0.3 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C8/10 X0; podrobná specifikace: nerelevantni
kabelové vedení-chránička | 4.70611 | 1 | no | ((-642508.38853503,-1062936.49683069,231.459175468269),(-642497.526297272,-1062931.16995849,231.644362823376)) | 216 | kabelové vedení-chránička | Barva_216 | kabelové vedení | 1123.3 | 1135.3 | chránička | 702212 | I1+S1+E1+Z1+M1+F1 | P1 | 127;0;127 | CZ_S1 - Reference: D.4.4.3; Materiál: PVC; specifikace: 125/103; podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 12
trubní vedení-obetonování | 21.1936 | 1 | no | ((-642508.470008306,-1062936.66570447,231.459175468269),(-642497.444823996,-1062931.0010847,231.719362823376)) | 8 | trubní vedení-obetonování | Barva_8 | trubní vedení | 1123.3 | 1135.3 | obetonování | 451114 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.05534 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: beton; specifikace: C25/30 XA1; podrobná specifikace: nerelevantni
zemní práce-výkop rýhy | 26.3752 | 1 | no | ((-642508.470008306,-1062936.66570447,231.409175468269),(-642497.444823996,-1062931.0010847,232.044362823376)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 1123.3 | 1135.3 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 3.45 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 20.1252 | 1 | no | ((-642508.470008306,-1062936.66570447,231.659175468269),(-642497.444823996,-1062931.0010847,232.044362823376)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 1123.3 | 1135.3 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 1.95 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 89.1709 | 1 | no | ((-642497.629496755,-1062979.6160448,230.987629788687),(-642408.312054824,-1062936.28292389,231.584175468269)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 1135.3 | 1234.3 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 3.465 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 79.2359 | 1 | no | ((-642497.629496755,-1062979.6160448,231.087629788687),(-642408.312054824,-1062936.28292389,231.634175468269)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 1135.3 | 1234.3 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 1.7325 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 168.651 | 1 | no | ((-642497.629496755,-1062979.6160448,230.987629788687),(-642408.312054824,-1062936.28292389,231.984175468269)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 1135.3 | 1234.3 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 17.325 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 138.846 | 1 | no | ((-642497.629496755,-1062979.6160448,231.137629788687),(-642408.312054824,-1062936.28292389,231.984175468269)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 1135.3 | 1234.3 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 12.1275 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 822.675 | 1 | no | ((-642403.960837339,-1063371.32352867,230.244500842231),(-641576.985781429,-1062981.47343444,231.895953206849)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 1239.3 | 2153.25 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 31.99 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 731.24 | 1 | no | ((-642403.960837339,-1063371.32352867,230.344500842231),(-641576.985781429,-1062981.47343444,231.945953206849)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 1239.3 | 2153.25 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 15.995 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 1554.16 | 1 | no | ((-642403.960837339,-1063371.32352867,230.244500842231),(-641576.985781429,-1062981.47343444,232.295953206849)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 1239.3 | 2153.25 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 159.95 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 1279.85 | 1 | no | ((-642403.960837339,-1063371.32352867,230.394500842231),(-641576.985781429,-1062981.47343444,232.295953206849)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 1239.3 | 2153.25 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 111.965 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 371.801 | 1 | no | ((-641570.7934479,-1063550.195624,230.617119686938),(-641197.049912289,-1063373.97237704,236.012131012933)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 2160.25 | 2573.18 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 14.455 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 330.466 | 1 | no | ((-641570.7934479,-1063550.195624,230.717119686938),(-641197.049912289,-1063373.97237704,236.062131012933)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 2160.25 | 2573.18 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 7.2275 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 702.481 | 1 | no | ((-641570.7934479,-1063550.195624,230.617119686938),(-641197.049912289,-1063373.97237704,236.412131012933)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 2160.25 | 2573.18 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 72.275 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 578.476 | 1 | no | ((-641570.7934479,-1063550.195624,230.767119686938),(-641197.049912289,-1063373.97237704,236.412131012933)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 2160.25 | 2573.18 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 50.5925 | objemová metoda | nerelevantni | 1
kabelové vedení-podkladní vrstva | 50.4814 | 1 | no | ((-640803.195006761,-1063756.31307141,236.712502714878),(-640751.70718675,-1063734.21099202,237.204979352404)) | 8 | kabelové vedení-podkladní vrstva | Barva_8 | kabelové vedení | 3008.13 | 3063.74 | podkladní vrstva | 45157 | I1+S1+E1+Z1+M3+F1 | P10 | 128;128;128 | 1.96 | objemová metoda | CZ_S1 - Reference: D.4.4.3; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
kabelové vedení-obsyp | 44.8464 | 1 | no | ((-640803.195006761,-1063756.31307141,236.812502714878),(-640751.70718675,-1063734.21099202,237.254979352404)) | 40 | kabelové vedení-obsyp | Barva_40 | kabelové vedení | 3008.13 | 3063.74 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | P2 | 255;165;0 | 0.98 | objemová metoda | CZ_M6 - Tloušťka: 0.15; CZ_S2 - Podrobná specifikace: nerelevantni; Reference: D.4.4.3; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni
zemní práce-výkop rýhy | 95.5614 | 1 | no | ((-640803.195006761,-1063756.31307141,236.712502714878),(-640751.70718675,-1063734.21099202,237.604979352404)) | 36 | zemní práce-výkop rýhy | Barva_36 | zemní práce | 3008.13 | 3063.74 | výkop rýhy | 132736 | I1+S3+E1+Z1+M3+F1 | P100 | 125;75;0 | 9.8 | objemová metoda | nerelevantni | 1
zemní práce-zásyp rýhy | 78.6564 | 1 | no | ((-640803.195006761,-1063756.31307141,236.862502714878),(-640751.70718675,-1063734.21099202,237.604979352404)) | 96 | zemní práce-zásyp rýhy | Barva_96 | zemní práce | 3008.13 | 3063.74 | zásyp rýhy | 17481 | I1+S3+E1+Z1+M3+F1 | P100 | 0;128;0 | 6.86 | objemová metoda | nerelevantni | 1
