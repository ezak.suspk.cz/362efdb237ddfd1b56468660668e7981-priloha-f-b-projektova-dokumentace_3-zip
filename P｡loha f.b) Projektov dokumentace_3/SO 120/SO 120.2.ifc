Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 120.2.ifc
Time: 2025-03-06T13:04:49
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 120
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (27)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu | Tloušťka | Označení stavebního objektu | Označení podobjektu | Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | Skupina elementů | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | podrobná specifikace | Reference | Materiál | specifikace
vozovka_chodník-krytová vrstva nezpevněných vozovek | 9166.46 | 1 | no | ((-640068.081658774,-1064092.43549438,229.344408530266),(-638925.207060891,-1063727.82100723,234.717112528794)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 1068.65 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12 | 1232.7 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
zemní práce-výkop_odkop | 8798.38 | 1 | no | ((-640068.081658774,-1064092.43549438,229.244408530266),(-638925.207060891,-1063727.82100723,234.467112528794)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 427.462 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12 | 1232.7 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-krytová vrstva nezpevněných vozovek | 1041.86 | 3 | no | ((-640063.82360106,-1064088.93549502,229.449408530266),(-638925.162905516,-1063727.9535019,234.666068149637)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 38.1406 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12 | 1232.74 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
zemní práce-výkop_odkop | 1270.96 | 1 | no | ((-640063.82360106,-1064088.93549502,229.349408530266),(-638925.162905516,-1063727.9535019,234.416068149637)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 48.8124 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12 | 1232.74 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-krytová vrstva nezpevněných vozovek | 0.797398 | 3 | no | ((-640068.339285199,-1063728.66123753,229.418908315667),(-640068.035474285,-1063727.81363246,229.68669193822)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 0.0270156 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12 | 12.84 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 316.622 | 3 | no | ((-640022.92614234,-1063852.45574151,229.449522354183),(-639665.89162093,-1063761.10575571,230.448092249653)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 11.6153 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 73.13 | 442.1 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 346.739 | 3 | no | ((-639622.551989692,-1063960.01179928,230.472101693138),(-639228.952831888,-1063864.10881083,233.106519302721)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 12.7035 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 487.11 | 892.1 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 231.569 | 3 | no | ((-639185.640295815,-1064092.59528211,232.856519302721),(-638952.09852697,-1063971.0957188,234.31866453758)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 8.49385 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 937.11 | 1205.96 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 4.53625 | 3 | no | ((-638929.852641356,-1064092.45360931,234.409205155626),(-638925.159651557,-1064088.65332549,234.717080205215)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 0.14428 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 1228.01 | 1232.74 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
zemní práce-výkop_odkop | 0.975338 | 1 | no | ((-640068.542294823,-1063728.66123753,229.312815532162),(-640068.035474285,-1063727.80782114,229.43669193822)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 0.0343206 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12 | 12.84 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 386.399 | 1 | no | ((-640022.966480973,-1063852.65160433,229.343429570678),(-639665.89162093,-1063761.10575571,230.208373803051)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 14.8375 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 73.13 | 442.1 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 423.16 | 1 | no | ((-639622.604108527,-1063960.2034858,230.372101693138),(-639228.952831888,-1063864.10881083,232.866800856119)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 16.2466 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 487.11 | 892.1 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 282.639 | 1 | no | ((-639185.694921391,-1064092.79630481,232.756519302721),(-638952.09852697,-1063971.0957188,234.06866453758)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 10.8522 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 937.11 | 1205.96 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 5.12676 | 1 | no | ((-638929.852641356,-1064092.65068082,234.304593790663),(-638925.157080931,-1064088.65332549,234.477361758613)) | 36 | zemní práce-výkop_odkop | Barva_36 | 125;75;0 | P100 | 0.185854 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 1228.01 | 1232.74 | výkop/odkop | zemní práce | 12373 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-krytová vrstva nezpevněných vozovek | 108.797 | 3 | no | ((-638952.109613309,-1064095.17707198,234.064902417454),(-638929.852532785,-1064092.21316466,234.753572799617)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 11.89 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 1205.97 | 1228.01 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-spodní podkladní vrstva | 250.463 | 2 | yes | ((-639666.03785308,-1063865.05394639,229.842490276731),(-639622.490697136,-1063852.20797797,230.552656784408)) | 256 | vozovka_chodník-spodní podkladní vrstva | ByLayer | 128;128;128 | P50 | 22.83 | řezová metoda | 0.2 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 442.1 | 487.1 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1
vozovka_chodník-spodní podkladní vrstva | 247.382 | 2 | yes | ((-639229.074741236,-1063971.9340709,232.656519302721),(-639185.575905406,-1063959.77642963,232.941993086358)) | 256 | vozovka_chodník-spodní podkladní vrstva | ByLayer | 128;128;128 | P50 | 22.57 | řezová metoda | 0.2 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 892.1 | 937.1 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1
vozovka_chodník-spodní podkladní vrstva | 120.561 | 1 | no | ((-638952.123193405,-1064095.47640753,233.861242166943),(-638929.848799579,-1064092.21316466,234.513854353015)) | 256 | vozovka_chodník-spodní podkladní vrstva | ByLayer | 128;128;128 | P50 | 10.94 | řezová metoda | 0.2 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 1205.97 | 1228.01 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-638929.908615285,-1064092.26300275,234.317072361684),(-638929.808615285,-1064092.16300275,234.417072361684)) | 9 | trasa-průjezdní a průchozí prostor | Barva_9 | 191;191;191 | P2 | CZ_I3 - Fáze projektu: PDPS; Název (trasy): Účelová komunikace; Staničení od: 1227.95; Staničení do: 1228.05; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 224.125 | 4 | yes | ((-639229.006345897,-1063971.65142116,232.856519302721),(-639185.575905406,-1063959.77642963,233.18171153296)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 24.66 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 892.1 | 937.1 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-spodní podkladní vrstva | 629.177 | 2 | yes | ((-640072.38698719,-1063763.38696841,228.992491004503),(-640022.877891409,-1063728.64810749,229.45836117179)) | 256 | vozovka_chodník-spodní podkladní vrstva | ByLayer | 128;128;128 | P50 | 59.43 | řezová metoda | 0.2 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12.84 | 73.13 | spodní podkladní vrstva | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 589.873 | 4 | yes | ((-640072.080820622,-1063763.08688321,229.201676571513),(-640022.877891409,-1063728.65686872,229.70836117179)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 68.33 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12.84 | 73.13 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 226.411 | 4 | yes | ((-639665.956883739,-1063864.77002763,230.051675843739),(-639622.490697136,-1063852.20797797,230.79237523101)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | 125;75;0 | P50 | 24.85 | řezová metoda | 0.25 | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 442.1 | 487.1 | krytová vrstva nezpevněných vozovek | vozovka/chodník | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA | ČSN 73 6126-1
zemní práce-sejmutí ornice | 128.514 | 3 | yes | ((-638952.123193405,-1064095.47640753,233.746191533084),(-638929.848799579,-1064092.21541891,234.92342517914)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 125;75;0 | P100 | 17.0733 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 1205.97 | 1228.01 | sejmutí ornice | zemní práce | 12110 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: ornice; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-sejmutí ornice | 651.763 | 3 | yes | ((-640072.38698719,-1063763.38696841,228.967284180147),(-640022.877891409,-1063728.64810749,229.661930612048)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 125;75;0 | P100 | 91.3304 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 12.84 | 73.13 | sejmutí ornice | zemní práce | 12110 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: ornice; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-sejmutí ornice | 266.543 | 3 | yes | ((-639666.03785308,-1063865.05394639,229.67296944245),(-639622.480690962,-1063852.20797797,230.45)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 125;75;0 | P100 | 35.8137 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 442.1 | 487.1 | sejmutí ornice | zemní práce | 12110 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: ornice; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-sejmutí ornice | 262.397 | 3 | yes | ((-639229.074741236,-1063971.9340709,232.375488679726),(-639185.575905406,-1063959.77642963,232.985850521203)) | 36 | zemní práce-sejmutí ornice | Barva_36 | 125;75;0 | P100 | 35.1885 | řezová metoda |  | SO 120 | SO 120.2 | nerelevantni | PDPS | Přístupová komunikace Kostěnice | OTSKP | 892.1 | 937.1 | sejmutí ornice | zemní práce | 12110 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: ornice; Třída těžitelnosti: 1; Další specifikace: nerelevantni

# IfcGeographicElement, zemní práce-pláň
In: UnknownName
PredefinedType: TERRAIN
Properties - AutoRebuild: yes; HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; FingerPrint: -473196476; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; IsUsed: yes; Name: zemní práce-pláň; ShowToolTip: yes; StyleName: plan; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; Bounds: ((-640172.38698719,-1064195.47640753,228.992491004503),(-638825.157080931,-1063627.80736262,234.380274379973)); AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; ColorIndex: 96; Layer: zemní práce-pláň; Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: Barva_96; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 120; Označení podobjektu: SO 120.2; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přístupová komunikace Kostěnice; Staničení od: 24.83; Staničení do: 1228.01; Označení elementu: pláň; Skupina elementů: zemní práce; Klasifikační systém: OTSKP; Označení položky: 18110; Označení šablony vlastností: I1+S1+E1+Z1+M2+F1
CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.8.4
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_Z1 - Textura / barva: 0;128;0; Skupina přesnosti: P10
CZ_M2 - Plocha: 5912.61; Způsob stanovení plochy: 3D plocha TIN povrchu
CZ_F1 - Fáze: trvalý stav
