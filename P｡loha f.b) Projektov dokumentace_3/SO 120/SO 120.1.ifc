Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 120.1.ifc
Time: 2025-06-18T12:35:06
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 120
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Souřadnicový systém: S-JTSK; Výškový systém: Bpv

# IfcBuiltElement (38)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | PlotStyleName | Layer | Tloušťka | Fáze | Označení stavebního objektu | Označení podobjektu | Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
vozovka_chodník-horní podkladní vrstva | 1644.8 | 1 | no | ((-641563.020121817,-1062961.55848431,231.70745981364),(-641456.584964381,-1062751.50030494,236.005834705678)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 153.466 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 1590.23 | 1 | no | ((-641563.020121817,-1062961.5584844,231.60745981614),(-641456.584964281,-1062751.50030494,235.805834705678)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 76.7329 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 707.929 | 2 | yes | ((-641494.682464931,-1062902.2667628,231.45745981989),(-641455.07,-1062751.50030496,235.213918748598)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 173.41 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 47.39 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 186.799 | 1 | no | ((-641563.101640981,-1062959.72143865,231.702331608511),(-641460.832423738,-1062751.46877714,235.945834705679)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 5.49789 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 203.405 | 1 | no | ((-641563.142400563,-1062959.72143865,231.599767505947),(-641460.832423738,-1062751.45301324,235.745834705679)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 6.87076 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 305.066 | 1 | no | ((-641563.203539936,-1062959.72143865,231.445921352101),(-641460.832423738,-1062751.42936739,235.645834705679)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.15 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 15.4554 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 1286.26 | 1 | no | ((-641562.229385927,-1062963.39552997,231.783947842497),(-641453.336907225,-1062752.27794335,236.065834705678)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 117.603 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 1231.51 | 1 | no | ((-641562.229385967,-1062963.39552997,231.683947844997),(-641453.336907225,-1062752.27794334,235.865834705678)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 58.8013 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 183.075 | 1 | no | ((-641561.438650038,-1062963.57388392,231.778819637369),(-641453.142848545,-1062752.5853394,236.065834705678)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 5.31156 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 197.914 | 1 | no | ((-641561.438650038,-1062963.66306089,231.676255534805),(-641453.045819205,-1062752.5853394,235.871659948396)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 6.64088 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 1605.33 | 1 | no | ((-641604.88164173,-1063344.35982327,231.169860194516),(-641561.438650038,-1062961.55848431,237.058000712517)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 144.826 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 1568.26 | 1 | no | ((-641606.625899829,-1063344.21817693,231.169860194516),(-641562.229385927,-1062959.72143865,237.005500712513)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 140.968 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 1605.33 | 1 | no | ((-641604.88164173,-1063344.35982327,230.969860194516),(-641561.438650038,-1062961.55848431,236.858000712517)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 144.826 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 1568.26 | 1 | no | ((-641606.625899829,-1063344.21817693,230.969860194516),(-641562.229385927,-1062959.72143865,236.805500712513)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 140.968 | řezová metoda
zemní práce-sanace | 1527.35 | 1 | no | ((-641604.88164173,-1063344.35982327,230.861110194516),(-641561.438650038,-1062961.55848431,236.658000712517)) | 40 | Barva_40 | zemní práce-sanace |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | zemní práce | sanace | 17180 | I1+S1+E1+Z1+M3+F1 | vhodná nebo podmínečně vhodná | D.1.8.4 | sypanina | ČSN 73 6133 | 255;165;0 | P2 | 72.4323 | řezová metoda
zemní práce-sanace | 1489.51 | 1 | no | ((-641606.625899829,-1063344.21817693,230.861110194516),(-641562.229385927,-1062959.72143865,236.605500712513)) | 40 | Barva_40 | zemní práce-sanace |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | zemní práce | sanace | 17180 | I1+S1+E1+Z1+M3+F1 | vhodná nebo podmínečně vhodná | D.1.8.4 | sypanina | ČSN 73 6133 | 255;165;0 | P2 | 70.503 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 274.742 | 1 | no | ((-641606.830354991,-1063344.0765306,231.164731989388),(-641563.020121817,-1062959.5320525,236.953000712512)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 8.10381 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 437.144 | 1 | no | ((-641607.034810152,-1063344.0765306,230.95960378426),(-641563.020121817,-1062959.34266635,236.753000712512)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 24.3175 | řezová metoda
zemní práce-sanace | 462.149 | 1 | no | ((-641607.148663486,-1063344.0765306,230.845375658434),(-641563.020121817,-1062959.24797327,236.553000712512)) | 40 | Barva_40 | zemní práce-sanace |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | zemní práce | sanace | 17180 | I1+S1+E1+Z1+M3+F1 | vhodná nebo podmínečně vhodná | D.1.8.4 | sypanina | ČSN 73 6133 | 255;165;0 | P2 | 18.2548 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 258.295 | 1 | no | ((-641603.137383631,-1063344.37642651,231.164731989388),(-641561.361879563,-1062963.39552997,237.058000712517)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 7.49043 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 408.184 | 1 | no | ((-641603.137383631,-1063344.39302974,230.95960378426),(-641561.285109088,-1062963.39552997,236.863825955236)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.2 | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 22.4658 | řezová metoda
zemní práce-sanace | 428.962 | 1 | no | ((-641603.137383631,-1063344.40227545,230.845375658434),(-641561.246723851,-1062963.39552997,236.669651197954)) | 40 | Barva_40 | zemní práce-sanace |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 280 | 670 | OTSKP | zemní práce | sanace | 17180 | I1+S1+E1+Z1+M3+F1 | vhodná nebo podmínečně vhodná | D.1.8.4 | sypanina | ČSN 73 6133 | 255;165;0 | P2 | 16.859 | řezová metoda
vozovka_chodník-krytová vrstva nezpevněných vozovek | 141.222 | 1 | no | ((-641480.21,-1062844.48447252,233.97),(-641462.73,-1062826.59403427,234.887447608847)) | 36 | Barva_36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | 0.15 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 86.28 | 106.7 | OTSKP | vozovka/chodník | krytová vrstva nezpevněných vozovek | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠD | ČSN 73 6126-1 | 125;75;0 | P2 | 9.92577 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 10.9245 | 1 | no | ((-641483.667038386,-1062752.61684929,231.314871794872),(-641475.831135439,-1062739.6,231.983952842505)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 0.14 | 10 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 0.321074 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 11.8812 | 1 | no | ((-641483.667038386,-1062752.6326196,231.212307692308),(-641475.766703159,-1062739.6,231.783952842505)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 0.14 | 10 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 0.400174 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 6.86328 | 1 | no | ((-641498.053389497,-1062751.55048204,231.541371901121),(-641490.642595959,-1062746.11,231.91)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 0.12 | 10.08 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 0.201341 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 7.43332 | 1 | no | ((-641498.075084246,-1062751.57579872,231.438807798557),(-641490.642595959,-1062746.11,231.71)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 0.12 | 10.12 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 0.249915 | řezová metoda
vozovka_chodník-horní podkladní vrstva | 221.299 | 1 | no | ((-641498.01,-1062752.58530866,231.32),(-641475.96,-1062739.6,232.033947842661)) | 8 | Barva_8 | vozovka_chodník-horní podkladní vrstva | 0.2 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 0.03 | 10 | OTSKP | vozovka/chodník | horní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDA fr. 0/63 | ČSN 73 6126-1 | 128;128;128 | P2 | 21.0016 | řezová metoda
vozovka_chodník-spodní podkladní vrstva | 215.736 | 1 | no | ((-641498.01,-1062752.58530866,231.22),(-641475.96,-1062739.6,231.833947842661)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 0.03 | 10 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 10.5008 | řezová metoda
vozovka_chodník-kryt z silničních dílců | 26.1108 | 2 | no | ((-641477.226196665,-1062906.30916522,234.858609059398),(-641472.387431232,-1062901.31128942,235.1286090594)) | 9 | Barva_9 | vozovka_chodník-kryt z silničních dílců | 0.15 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 173.41 | 176.43 | OTSKP | vozovka/chodník | kryt z silničních dílců | 58300 | I1+S1+E1+Z1+M3;2&6+F1 | min. tl. 15 cm, nosnost 20 t | D.1.8.4 | ŽB silniční panel | nerelevantni | 191;191;191 | P2 | 1.8 | řezová metoda
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-641485.990813566,-1062742.6127535,231.557162161211),(-641485.850071595,-1062742.46865069,231.662837838499)) | 9 | Barva_9 | trasa-průjezdní a průchozí prostor |  | trvalý stav |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 191;191;191 | P2 | CZ_I3 - Fáze projektu: PDPS; Staničení od: 0; Název (trasy): Účelová komunikace; Staničení do: 0.1; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
vozovka_chodník-spodní podkladní vrstva | 423.031 | 2 | yes | ((-641563.020121777,-1062961.23720674,234.835370339939),(-641476.508563237,-1062903.18551985,235.696173904875)) | 8 | Barva_8 | vozovka_chodník-spodní podkladní vrstva | 0.1 | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 176.43 | 280 | OTSKP | vozovka/chodník | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.1.8.4 | ŠDB | ČSN 73 6126-1 | 128;128;128 | P2 | 29.35 | řezová metoda
zemní práce-výkop_odkop | 1222.97 | 4 | no | ((-641563.020121718,-1062961.23720674,231.45745981989),(-641453.337740779,-1062751.50030498,235.846245523994)) | 36 | Barva_36 | zemní práce-výkop_odkop |  | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 10 | 280 | OTSKP | zemní práce | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 156.023 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-sejmutí ornice | 3373.06 | 6 | no | ((-641606.872409649,-1063344.37008151,230.853436220103),(-641561.145354799,-1062963.44825776,236.906850710474)) | 36 | Barva_36 | zemní práce-sejmutí ornice |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 290 | 670 | OTSKP | zemní práce | sejmutí ornice | 121101 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 541.95 | objemová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 2800.98 | 7 | no | ((-641606.872409649,-1063344.28931094,230.853436220103),(-641561.343308878,-1062963.55322041,236.565528230061)) | 36 | Barva_36 | zemní práce-výkop_odkop |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 290 | 670 | OTSKP | zemní práce | výkop/odkop | 12373 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 72.9011 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-rozprostření ornice (ohumusovani) | 3373.06 | 5 | no | ((-641606.872409649,-1063344.37008151,230.853436220103),(-641561.145354799,-1062963.44825776,236.906850710474)) | 73 | Barva_73 | zemní práce-rozprostření ornice (ohumusovani) |  | dočasný stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 290 | 670 | OTSKP | zemní práce | sejmutí ornice | 18230 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 541.95 | objemová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
dopravní značení-směrový sloupek | 0.211115 | 13 | yes | ((-641495.953186893,-1062747.00370988,231.709999999776),(-641495.873186893,-1062746.92370988,232.509999999776)) | 7 | Barva_7 | dopravní značení-směrový sloupek |  | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 2 | 2 | OTSKP | dopravní značení | směrový sloupek | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | 255;255;255 | P10 | CZ_S2 - Reference: D.1.8.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 g; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-směrový sloupek | 0.211115 | 4 | yes | ((-641477.066920421,-1062741.02924154,231.409999999776),(-641476.986920421,-1062740.94924154,232.209999999776)) | 7 | Barva_7 | dopravní značení-směrový sloupek |  | trvalý stav | SO 120 | SO 120.1 | nerelevantni | PDPS | Přístupová komunikace Zminný | 2 | 2 | OTSKP | dopravní značení | směrový sloupek | 91228 | I1+S2+E1+Z1+M4+F1 |  |  |  |  | 255;255;255 | P10 | CZ_S2 - Reference: D.1.8.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11 g; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu

# IfcGeographicElement (5)
In: UnknownName
PredefinedType: TERRAIN
Properties - HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Ikona)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 120; Označení podobjektu: SO 120.1; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přístupová komunikace Zminný; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | AutoRebuild = IsUsed | FingerPrint | Name | StyleName | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Plocha | Způsob stanovení plochy | Fáze
zemní práce-pláň-1 | yes | -476075188 | zemní práce-pláň-1 | plan | ((-641706.830354991,-1063444.37642651,231.164731989388),(-641353.045819205,-1062651.42936739,236.863825955236)) | 96 | zemní práce-pláň | Barva_96 | 10 | 280 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | nerelevantni | nerelevantni | nerelevantni | D.1.8.4 | 0;128;0 | P10 | 1601.62 | 3D plocha TIN povrchu | trvalý stav
zemní práce-pláň-2 | yes | -971641438 | zemní práce-pláň-2 | plan | ((-641707.148663486,-1063444.40227545,230.845375658434),(-641353.037076571,-1062658.11056391,236.572563819314)) | 96 | zemní práce-pláň | Barva_96 | 290 | 670 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | nerelevantni | nerelevantni | nerelevantni | D.1.8.4 | 0;128;0 | P10 | 1816.8 | 3D plocha TIN povrchu | trvalý stav
vozovka_chodník-nátěry | yes | 1160382951 | vozovka_chodník-nátěry | nátěry | ((-641706.625899829,-1063444.35982327,231.369860194516),(-641353.336907225,-1062639.6,237.058000712517)) | 8 | vozovka_chodník-nátěry | Barva_8 | 0.62 | 280 | nátěry | vozovka/chodník | 572743 | I1+S1+E1+Z1+M2+F1 | Dvojvrstvý nátěr z kat. em. | ČSN 73 6129 | nerelevantni | D.1.8.4 | 128;128;128 | P2 | 1461.3 | 3D plocha TIN povrchu | trvalý stav
vozovka_chodník-geosyntetikum | yes | -1057719643 | vozovka_chodník-geosyntetikum | geotextilie | ((-641707.152194921,-1063444.40259586,230.845375658434),(-641353.037076571,-1062658.11056391,236.904886100574)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | 286 | 670 | geosyntetikum | vozovka/chodník | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie separační | TP 97 | typ S1 min. 400 g/m2 | D.1.8.4 | 127;0;127 | P2 | 2063.02 | 3D plocha TIN povrchu | dočasný stav
dopravní značení-vodorovné dopravní značení (1) (1) | no | 1436348804 | dopravní značení-vodorovné dopravní značení (1) (1) | vdz | ((-641598.214112233,-1062845.71844762,231.52),(-641376.097489839,-1062639.1641095,231.76)) | 7 | dopravní značení-vodorovné dopravní značení | Barva_7 | 0 | 0 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;255;255 | P10 |  |  | trvalý stav | Description: Popis; Properties - Description: Popis; CZ_S2 - Typ stavebního výrobku: VDZ; Stavební výrobek: V4; Specifikace: barva; Podrobná specifikace: TP 133; Reference: D.1.8.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 23; Způsob stanovení délky: Délka 3D křivky
