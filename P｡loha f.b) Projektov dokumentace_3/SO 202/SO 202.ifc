Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 202.ifc
Time: 2025-05-26T11:03:55
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 202
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (9)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 202; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Zárubní zeď; Staničení do: 206; Klasifikační systém: OTSKP; Staničení od: 0
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
odvodnění-podkladní beton | 662.7 | 2 | yes | ((-642365.305968712,-1063078.838596,230.2),(-642179.244749356,-1062985.98557591,230.3)) | 9 | odvodnění-podkladní beton | Barva_9 | podkladní beton | odvodnění | 451312 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.2.2.4 | beton | C12/15 | 191;191;191 | P100 | 31.05 | řezová metoda
založení-patka _ pás | 745 | 2 | yes | ((-642364.952773562,-1063078.50502586,230.3),(-642179.578283453,-1062986.33877106,231.1)) | 6 | založení-patka _ pás | Barva_6 | patka / pás | založení | 272314 | I1+S1;4+E1+Z1+M3+F1 | nerelevantni | D.2.2.4 | beton | nerelevantni | 255;0;255 | P10 | 165.2 | řezová metoda | CZ_S4 - Beton: C25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.2.2.4; Návrhová životnost: 25
podpěra-dřík | 692.511 | 1 | no | ((-642364.599578412,-1063078.17143234,231.1),(-642179.911817549,-1062986.69196621,232.6)) | 9 | podpěra-dřík | Barva_9 | dřík | podpěra | 327325 | I1+S1;4+E1+Z1+M3+F1 | nerelevantni | D.2.2.4 | ŽB | nerelevantni | 191;191;191 | P1 | 121.499 | řezová metoda | CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 120; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.2.2.4; Návrhová životnost: 25
římsa-římsa | 366.356 | 1 | no | ((-642364.667035077,-1063078.26158652,231.6),(-642179.911817549,-1062986.69196621,232.9)) | 40 | římsa-římsa | Barva_40 | římsa | římsa | 317325 | I1+S1;4+E1+Z1+M3+F1 | nerelevantni | D.2.2.4 | ŽB | nerelevantni | 255;165;0 | P1 | 35.5987 | řezová metoda | CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 120; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.2.2.4; Návrhová životnost: 25
odvodnění-drenážní potrubí | 97.0637 | 2 | yes | ((-642364.245431447,-1063077.69812306,231.325000836593),(-642179.836094879,-1062986.56277837,231.875000738112)) | 176 | odvodnění-drenážní potrubí | Barva_176 | drenážní potrubí | odvodnění | 21263 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;0;128 | P10 | CZ_S2 - Reference: D.2.2.4; Specifikace: nerelevantni; Typ stavebního výrobku: drenáž; Stavební výrobek: plast DN150; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 206; Způsob stanovení délky: Délka 3D křivky
odvodnění-podkladní beton | 473.692 | 1 | no | ((-642364.262295088,-1063077.72066143,231.175),(-642179.479125554,-1062985.95375226,231.755)) | 9 | odvodnění-podkladní beton | Barva_9 | podkladní beton | odvodnění | 451312 | I1+S1+E1+Z1+M3+F1 | nerelevantni | D.2.2.4 | beton | C12/15 | 191;191;191 | P100 | 30.8601 | řezová metoda
zemní práce-rozprostření ornice (ohumusovani) | 562.552 | 1 | no | ((-642364.262295088,-1063077.72066143,231.5),(-642179.479125554,-1062985.95375226,232.8)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | rozprostření ornice (ohumusovani) | zemní práce | 18230 | I1+S1+E1+Z1+M3;2&6+F1 | nerelevantni | D.2.2.4 | ornice | nerelevantni | 165;207;99 | P100 | 65.7581 | řezová metoda | CZ_M6 - Tloušťka: 0.3
zemní práce-výkop_odkop | 1709.42 | 1 | no | ((-642364.943607403,-1063078.63121866,230.1),(-642179.546956844,-1062985.94833527,232.80054016795)) | 36 | zemní práce-výkop_odkop | Barva_36 | výkop/odkop | zemní práce | 13173 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | 858.889 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zásypy a obsypy | 1688.38 | 2 | yes | ((-642364.916206358,-1063100.47097308,230.299999999232),(-642179.287338,-1062963.98598737,232.5)) | 40 | propustky-zásypy a obsypy | Barva_40 | zásypy a obsypy | propustky | 171101 | I1+S1;3+E1+Z1+M3+F1 | nerelevantni | D.2.2.4 | zemina | nerelevantni | 255;165;0 | P50 | 315.53 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni

# IfcGeographicElement (2)
In: UnknownName
PredefinedType: TERRAIN
Properties - AutoRebuild: yes; HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceObject: no; IsReferenceStale: no; IsReferenceSubObject: no; IsReferenceValid: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Icon)
General - LayerKey: AeccSurfaceTin; Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 202; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Zárubní zeď; Staničení do: 206; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_M2 - Plocha: 315.544; Způsob stanovení plochy: 3D plocha TIN povrchu
CZ_F1 - Fáze: trvalý stav
Name | FingerPrint | IsUsed | Name = Layer | StyleName | Bounds | ColorIndex | PlotStyleName | Staničení od | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti
hydroizolace-hydroizolační souvrství | 1024980473 | yes | hydroizolace-hydroizolační souvrství | Izolace | ((-642464.262295088,-1063177.72066143,231.1),(-642079.80364455,-1062886.50741272,232.9)) | 2 | Barva_2 | 30.07 | hydroizolační souvrství | hydroizolace | 711112 | I1+S7+E1+Z1+M2+F1 | 255;255;0 | PX | CZ_S7 - Hydroizolační souvrství: 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 0
vozovka_chodník-geosyntetikum | -211285498 | no | vozovka_chodník-geosyntetikum | geotextilie | ((-642464.262295088,-1063177.72066143,231.1),(-642079.80364455,-1062886.50741272,232.6)) | 216 | Barva_216 | 0 | geosyntetikum | vozovka/chodník | 711509 | I1+S1+E1+Z1+M2+F1 | 127;0;127 | P2 | CZ_S1 - Materiál: geotextilie; specifikace: min. 300g/m2; podrobná specifikace: nerelevantni; Reference: D.2.2.4
