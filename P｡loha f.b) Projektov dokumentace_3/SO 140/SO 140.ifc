Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 140.ifc
Time: 2025-06-18T14:39:32
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 140
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (73)
In: UnknownName
Properties - IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | ColorIndex | Layer | PlotStyleName | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | Skupina elementů | CZ_I1, Klasifikační systém | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Plocha | Způsob stanovení plochy
propustky-obetonování | 31.2849 | 2 | no | ((-639821.712139127,-1063462.21690028,229.313640743029),(-639815.42205938,-1063458.95445865,229.536290990681)) | 8 | propustky-obetonování | Barva_8 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | obetonování | propustky | OTSKP | 451385 | I1+S1+E1+Z1+M3+F1 | beton | C30/37 XF4 + síť kari KY49 | nerelevantni | D.1.10.4 | 128;128;128 | P50 | CZ_M3 - Objem: 2.37604; Způsob stanovení objemu: řezová metoda
propustky-podkladní vrstva | 40.5947 | 2 | no | ((-639821.756592307,-1063462.61459125,226.503682354699),(-639815.348758386,-1063458.56108871,226.736332454126)) | 2 | propustky-podkladní vrstva | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní vrstva | propustky | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP fr. 0/8 mm | nerelevantni | 95% PS | D.1.10.4 | 255;255;0 | P50 | CZ_M3 - Objem: 3.60005; Způsob stanovení objemu: řezová metoda
založení-patka _ pás | 35.8805 | 2 | no | ((-639821.720635073,-1063462.36734945,226.703679392814),(-639815.38579203,-1063458.80816928,226.936329492387)) | 6 | založení-patka _ pás | Barva_6 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | patka / pás | založení | OTSKP | 451384 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 255;0;255 | P10 | CZ_M3 - Objem: 3.24005; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C 25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
propustky-zásypy a obsypy | 27.5614 | 2 | yes | ((-639821.195623118,-1063459.82294042,226.704483873144),(-639815.337082028,-1063457.50028909,227.830296282165)) | 40 | propustky-zásypy a obsypy | Barva_40 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zásypy a obsypy | propustky | OTSKP | 17411 | I1+S1;3+E1+Z1+M3+F1 | jemnozrnný materiál a vyzískaný materiál | 95% PS | nerelevantni | D.1.10.4 | 255;165;0 | P50 | CZ_M3 - Objem: 5.55; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
odvodnění-podkladní beton | 20.8952 | 2 | no | ((-639821.938541328,-1063463.78347882,227.753596360098),(-639815.769185996,-1063461.32922951,227.98380231347)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní beton | odvodnění | OTSKP | 451311 | I1+S1+E1+Z1+M3+F1 | beton | C8/10 | nerelevantni | D.1.10.4 | 191;191;191 | P100 | CZ_M3 - Objem: 1.38562; Způsob stanovení objemu: řezová metoda
odvodnění-podkladní beton | 20.8952 | 2 | no | ((-639821.348273957,-1063459.84463664,227.753596360098),(-639815.180237466,-1063457.39018979,227.983802313469)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní beton | odvodnění | OTSKP | 451311 | I1+S1+E1+Z1+M3+F1 | beton | C8/10 | nerelevantni | D.1.10.4 | 191;191;191 | P100 | CZ_M3 - Objem: 1.38562; Způsob stanovení objemu: řezová metoda
propustky-zásypy a obsypy | 27.5614 | 2 | yes | ((-639821.772574175,-1063463.67474598,226.704483872785),(-639815.914032993,-1063461.35209463,227.830296282224)) | 40 | propustky-zásypy a obsypy | Barva_40 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zásypy a obsypy | propustky | OTSKP | 17411 | I1+S1;3+E1+Z1+M3+F1 | jemnozrnný materiál a vyzískaný materiál | 95% PS | nerelevantni | D.1.10.4 | 255;165;0 | P50 | CZ_M3 - Objem: 5.55; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-propust | 107.103 | 2 | no | ((-639821.711331818,-1063462.21884314,226.903676431161),(-639815.409088628,-1063458.95457957,229.336293952326)) | 8 | propustky-propust | Barva_8 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | propust | propustky | OTSKP | 91843 | I1+S1;2+E1+Z1+M1+F1 | prefa ŽB | nerelevantni | nerelevantni | D.1.10.4 | 128;128;128 | P10 | CZ_S2 - Reference: D.1.10.4; Typ stavebního výrobku: rámový propustek; Stavební výrobek: propustek; Specifikace: ŽB sv. 2,0/2,0 m; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 6; Způsob stanovení délky: Délka 3D křivky
propustky-čelo | 60.8663 | 2 | no | ((-639816.328809918,-1063465.0396372,226.839999999627),(-639814.501115117,-1063456.064865,229.76999999986)) | 256 | propustky-čelo | ByLayer | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | čelo | propustky | OTSKP | 918115 | I1+S1;4+E1+Z1+M3;4+F1 | ŽB | nerelevantni | nerelevantni | D.1.10.4 | 191;191;191 | P50 | CZ_M3 - Objem: 10.902; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 120; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
propustky-čelo | 61.2881 | 2 | no | ((-639822.460406635,-1063464.12120282,226.799999999814),(-639820.632711833,-1063455.14643062,229.730000000047)) | 256 | propustky-čelo | ByLayer | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | čelo | propustky | OTSKP | 918115 | I1+S1;4+E1+Z1+M3;4+F1 | ŽB | nerelevantni | nerelevantni | D.1.10.4 | 191;191;191 | P50 | CZ_M3 - Objem: 10.902; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 120; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
římsa-římsa | 19.067 | 2 | no | ((-639816.328809918,-1063465.07670482,229.769999999563),(-639814.253646488,-1063456.064865,230.068933485903)) | 40 | římsa-římsa | Barva_40 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | římsa | římsa | OTSKP | 317325 | I1+S1;4+E1+Z1+M3+F1 | ŽB | nerelevantni | nerelevantni | D.1.10.4 | 255;165;0 | P50 | CZ_M3 - Objem: 1.91757; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 120; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
římsa-římsa | 19.067 | 2 | no | ((-639822.707875266,-1063464.12120282,229.729999999718),(-639820.632711833,-1063455.109363,230.028933486039)) | 40 | římsa-římsa | Barva_40 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | římsa | římsa | OTSKP | 317325 | I1+S1;4+E1+Z1+M3+F1 | ŽB | nerelevantni | nerelevantni | D.1.10.4 | 255;165;0 | P50 | CZ_M3 - Objem: 1.91757; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C30/37 XF4+XD3; Specifikace: nerelevantni; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 120; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
založení-patka _ pás | 39.92 | 2 | no | ((-639822.843578802,-1063464.42029173,225.999999999762),(-639820.249539664,-1063454.84734172,226.800000000246)) | 6 | založení-patka _ pás | Barva_6 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | patka / pás | založení | OTSKP | 27231A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 255;0;255 | P10 | CZ_M3 - Objem: 9.12; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C 25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
založení-patka _ pás | 39.92 | 2 | no | ((-639816.711982086,-1063465.33872611,226.039999999575),(-639814.117942948,-1063455.76577609,226.84000000006)) | 6 | založení-patka _ pás | Barva_6 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | patka / pás | založení | OTSKP | 27231A | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 255;0;255 | P10 | CZ_M3 - Objem: 9.12; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C 25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
odvodnění-podkladní beton | 35.26 | 2 | no | ((-639816.974037346,-1063465.47465647,225.939999999488),(-639813.855887687,-1063455.62984573,226.039999999814)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní beton | odvodnění | OTSKP | 451312 | I1+S1+E1+Z1+M3+F1 | beton | C12/15 | nerelevantni | D.1.10.4 | 191;191;191 | P100 | CZ_M3 - Objem: 1.649; Způsob stanovení objemu: řezová metoda
odvodnění-podkladní beton | 35.26 | 2 | no | ((-639823.105634063,-1063464.55622209,225.899999999674),(-639819.987484404,-1063454.71141135,226)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní beton | odvodnění | OTSKP | 451312 | I1+S1+E1+Z1+M3+F1 | beton | C12/15 | nerelevantni | D.1.10.4 | 191;191;191 | P100 | CZ_M3 - Objem: 1.649; Způsob stanovení objemu: řezová metoda
záchytné systémy-zábradlí | 3.69589 | 2 | no | ((-639822.436921487,-1063463.89592122,230.014959862355),(-639821.007212314,-1063455.31913465,231.117459862413)) | 4 | záchytné systémy-zábradlí | Barva_4 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zábradlí | záchytné systémy | OTSKP | 9111A1 | I1+S2+E1+Z1+M1;5+F1 |  |  |  |  | 0;255;255 | P10 | CZ_S2 - Reference: D.1.10.4; Typ stavebního výrobku: zábradlí; Stavební výrobek: silniční ocelové zábradlí dvoumadlové; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 8.5; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
záchytné systémy-zábradlí | 3.69589 | 2 | no | ((-639817.179437414,-1063464.88817818,230.054959861415),(-639813.299472306,-1063456.26890162,231.157459863354)) | 4 | záchytné systémy-zábradlí | Barva_4 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zábradlí | záchytné systémy | OTSKP | 9111A1 | I1+S2+E1+Z1+M1;5+F1 |  |  |  |  | 0;255;255 | P10 | CZ_S2 - Reference: D.1.10.4; Typ stavebního výrobku: zábradlí; Stavební výrobek: silniční ocelové zábradlí dvoumadlové; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 8.5; Způsob stanovení délky: Délka 3D křivky; CZ_M5 - Hmotnost: 1; Způsob stanovení hmotnosti: odečet z modelu
propustky-zpevnění dlažbou | 56.5312 | 1 | no | ((-639815.626937907,-1063464.18836758,226.94),(-639811.148221566,-1063457.52348639,228.8)) | 8 | propustky-zpevnění dlažbou | Barva_8 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zpevnění dlažbou | propustky | OTSKP | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen spárováno MC | tl. 200 mm správáno MC25 XF4 | nerelevantni | D.1.10.4 | 128;128;128 | P50 | 26.3056 | 3D plocha TIN povrchu
propustky-zpevnění dlažbou | 54.5712 | 1 | no | ((-639815.626937907,-1063464.18836758,227.04),(-639811.148221566,-1063457.52348639,228.8)) | 8 | propustky-zpevnění dlažbou | Barva_8 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zpevnění dlažbou | propustky | OTSKP | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen spárováno MC | tl. 200 mm správáno MC25 XF4 | nerelevantni | D.1.10.4 | 128;128;128 | P50 | 26.3056 | 3D plocha TIN povrchu
propustky-lože | 54.5712 | 1 | no | ((-639815.626937907,-1063464.18836758,226.84),(-639811.148221566,-1063457.52348639,228.6)) | 16 | propustky-lože | Barva_16 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | lože | propustky | OTSKP | 45131A | I1+S1+E1+Z1+M2+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 128;0;0 | P50 | CZ_M3 - Objem: 2.232; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
propustky-podkladní vrstva | 54.5712 | 1 | no | ((-639815.626937907,-1063464.18836758,226.74),(-639811.148221566,-1063457.52348639,228.5)) | 2 | propustky-podkladní vrstva | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní vrstva | propustky | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP fr. 0/8 mm | nerelevantni | 95% PS | D.1.10.4 | 255;255;0 | P50 | CZ_M3 - Objem: 2.232; Způsob stanovení objemu: řezová metoda
2 x propustky-zpevnění dlažbou | 57.0692 | 1 | no | ((-639825.813300194,-1063462.66258144,226.88),(-639821.334583853,-1063455.99770024,228.8)) | 8 | propustky-zpevnění dlažbou | Barva_8 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zpevnění dlažbou | propustky | OTSKP | 465512 | I1+S1+E1+Z1+M2+F1 | lomový kámen spárováno MC | tl. 200 mm správáno MC25 XF4 | nerelevantni | D.1.10.4 | 128;128;128 | P50 | 26.5746 | 3D plocha TIN povrchu
propustky-lože | 55.1092 | 1 | no | ((-639825.813300194,-1063462.66258144,226.78),(-639821.334583853,-1063455.99770024,228.6)) | 16 | propustky-lože | Barva_16 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | lože | propustky | OTSKP | 45131A | I1+S1+E1+Z1+M2+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 128;0;0 | P50 | CZ_M3 - Objem: 2.232; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C20/25nXF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
propustky-podkladní vrstva | 55.1092 | 1 | no | ((-639825.813300194,-1063462.66258144,226.68),(-639821.334583853,-1063455.99770024,228.5)) | 2 | propustky-podkladní vrstva | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | podkladní vrstva | propustky | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 | ŠP fr. 0/8 mm | nerelevantni | 95% PS | D.1.10.4 | 255;255;0 | P50 | CZ_M3 - Objem: 2.232; Způsob stanovení objemu: řezová metoda
hydroizolace-hydroizolační souvrství | 86.1307 | 2 | no | ((-639821.552627559,-1063462.20635138,226.904486834347),(-639815.55702877,-1063458.96868365,229.545537260707)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 43.1 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 45.145 | 2 | no | ((-639816.33869959,-1063464.96556991,226.839999999622),(-639814.995598723,-1063456.06338366,229.769999999627)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 22.5 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 4.79287 | 2 | no | ((-639816.33869966,-1063464.96556991,229.769999999622),(-639814.995598724,-1063456.06338366,230.025986238119)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 2.4 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 45.0837 | 2 | no | ((-639821.965923029,-1063464.12268417,226.800000000042),(-639820.622822161,-1063455.22049792,229.730000000047)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 22.5 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 4.79287 | 2 | no | ((-639821.965923029,-1063464.12268417,229.730000000042),(-639820.622822161,-1063455.22049792,229.98598623855)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 2.4 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 2.9986 | 2 | no | ((-639822.461887981,-1063464.1310925,226.799999999814),(-639821.965923027,-1063464.04713553,229.730000000047)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 1.5 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 2.9986 | 2 | no | ((-639816.330291264,-1063465.04952687,226.839999999627),(-639815.834326311,-1063464.96556991,229.76999999986)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 1.5 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 2.9986 | 2 | no | ((-639814.995598724,-1063456.13893229,226.839999999627),(-639814.499633771,-1063456.05497533,229.76999999986)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 1.5 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 2.9986 | 2 | no | ((-639821.127195441,-1063455.22049791,226.799999999814),(-639820.631230487,-1063455.13654095,229.730000000047)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 1.5 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 24.986 | 2 | no | ((-639822.470296376,-1063464.04713552,226.799999999809),(-639821.127195439,-1063455.14494927,229.729999999886)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 12.25 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 24.544 | 2 | no | ((-639815.834326312,-1063465.04111855,226.83999999986),(-639814.491225376,-1063456.13893229,229.769999999922)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 12.25 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 6.847 | 2 | no | ((-639815.871359956,-1063465.33872611,226.839999999855),(-639814.117942948,-1063455.89169049,226.85000000006)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 3.325 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 6.847 | 2 | no | ((-639816.711982086,-1063465.21281171,226.839999999622),(-639814.958565079,-1063455.76577609,226.849999999627)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 3.325 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 6.847 | 2 | no | ((-639822.002956672,-1063464.42029173,226.800000000041),(-639820.249539664,-1063454.97325611,226.810000000246)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 3.325 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 6.847 | 2 | no | ((-639822.843578802,-1063464.29437734,226.799999999808),(-639821.090161795,-1063454.84734172,226.810000000014)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 3.325 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 9.7 | 2 | no | ((-639816.365843562,-1063465.286879,226.839999999855),(-639814.464081473,-1063455.8176232,226.84999999986)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 4.75 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
hydroizolace-hydroizolační souvrství | 9.7 | 2 | no | ((-639822.497440278,-1063464.36844463,226.799999999814),(-639820.595678189,-1063454.89918882,226.810000000246)) | 2 | hydroizolace-hydroizolační souvrství | Barva_2 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | hydroizolační souvrství | hydroizolace | OTSKP | 711112 | I1+S7+E1+Z1+M2+F1 |  |  |  |  | 255;255;0 | P10 | 4.75 | 3D plocha TIN povrchu | CZ_S7 - Hydroizolační souvrství: nátěr + 1xNAIP; Podkladní vrsta: 0; Hydroizolační vrstva: 0; Ochranná vrstva: 0; Množství výztuže ochranné vrstvy: 0; Návrhová životnost: 25
zemní práce-výkop_odkop | 174.981 | 2 | no | ((-639817.645698259,-1063466.08887946,225.939999999488),(-639812.982423454,-1063455.0364654,229.000000000013)) | 36 | zemní práce-výkop_odkop | Barva_36 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | výkop/odkop | zemní práce | OTSKP | 12273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | CZ_M3 - Objem: 58.747; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 176.773 | 2 | no | ((-639823.973029469,-1063465.14960242,225.899999999645),(-639819.313230287,-1063454.09793853,228.990215939454)) | 36 | zemní práce-výkop_odkop | Barva_36 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | výkop/odkop | zemní práce | OTSKP | 12273 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | CZ_M3 - Objem: 60.3663; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-krytová vrstva nezpevněných vozovek | 196.968 | 1 | no | ((-639822.647342063,-1063469.514819,228.500276780967),(-639814.640075745,-1063452.8469766,229.830000000075)) | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | krytová vrstva nezpevněných vozovek | vozovka/chodník | OTSKP | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | štěrkodrť | ČSN 73 6126-1 | nerelevantni | D.1.10.4 | 125;75;0 | P2 | CZ_M3 - Objem: 27.3605; Způsob stanovení objemu: řezová metoda; CZ_M6 - Tloušťka: 0.3
založení-patka _ pás | 29.8355 | 1 | no | ((-639826.26814091,-1063463.05816832,226.48),(-639821.275330022,-1063455.54285953,228.8)) | 6 | založení-patka _ pás | Barva_6 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | patka / pás | založení | OTSKP | 467314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 255;0;255 | P10 | CZ_M3 - Objem: 3.408; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C 25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
založení-patka _ pás | 29.7558 | 1 | no | ((-639815.686191738,-1063464.6432083,226.56),(-639810.69338085,-1063457.1278995,228.8)) | 6 | založení-patka _ pás | Barva_6 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | patka / pás | založení | OTSKP | 467314 | I1+S1;4+E1+Z1+M3+F1 | beton | nerelevantni | nerelevantni | D.1.10.4 | 255;0;255 | P10 | CZ_M3 - Objem: 3.408; Způsob stanovení objemu: řezová metoda; CZ_S4 - Beton: C 25/30 XF3; Specifikace: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.10.4; Návrhová životnost: 25
odvodnění-drenážní potrubí | 3.0255 | 2 | no | ((-639822.06932857,-1063462.37620892,227.904727313759),(-639815.771887184,-1063461.2879185,228.089256858032)) | 176 | odvodnění-drenážní potrubí | Barva_176 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | drenážní potrubí | odvodnění | OTSKP | 21263 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;0;128 | P10 | CZ_S2 - Reference: D.1.10.4; Typ stavebního výrobku: drenážná potrubí; Stavební výrobek: plast potrubí DN150 děrované; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 6.5; Způsob stanovení délky: Délka 3D křivky
odvodnění-drenážní potrubí | 3.0255 | 2 | no | ((-639821.688622707,-1063459.83456318,227.904727313759),(-639815.391181321,-1063458.74627277,228.089256858031)) | 176 | odvodnění-drenážní potrubí | Barva_176 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | drenážní potrubí | odvodnění | OTSKP | 21263 | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;0;128 | P10 | CZ_S2 - Reference: D.1.10.4; Typ stavebního výrobku: drenážná potrubí; Stavební výrobek: plast potrubí DN150 děrované; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M1 - Délka: 6.5; Způsob stanovení délky: Délka 3D křivky
zemní práce-rozprostření ornice (ohumusovani) | 40.8476 | 1 | no | ((-639823.301239068,-1063469.514819,228.5),(-639813.660282487,-1063452.8469766,229.58)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | rozprostření ornice (ohumusovani) | zemní práce | OTSKP | 18230 | I1+S1+E1+Z1+M3;2&6+F1 | ornice | nerelevantni | nerelevantni | D.1.10.4 | 165;207;99 | P100 | CZ_M3 - Objem: 2.69977; Způsob stanovení objemu: řezová metoda; CZ_M6 - Tloušťka: 0.1
zemní práce-sejmutí ornice | 212.843 | 1 | no | ((-639826.949559951,-1063472.55578801,228.320000000015),(-639811.907985643,-1063463.15672837,228.898045904599)) | 36 | zemní práce-sejmutí ornice | Barva_36 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | sejmutí ornice | zemní práce | OTSKP | 12110 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | CZ_M3 - Objem: 39.3373; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: ornice; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zásypy a obsypy | 173.599 | 2 | yes | ((-639822.491445823,-1063468.45335563,227.904501643104),(-639814.76690447,-1063453.67737531,229.530000000359)) | 40 | propustky-zásypy a obsypy | Barva_40 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | zásypy a obsypy | propustky | OTSKP | 17180 | I1+S1;3+E1+Z1+M3+F1 | recyklovaný materiál fr. 0/63 | ČSN 73 6133 | 95% PS | D.1.10.4 | 255;165;0 | P50 | CZ_M3 - Objem: 58.98; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-sejmutí ornice | 289.397 | 1 | no | ((-639826.371658561,-1063465.82930976,226.67),(-639810.608754602,-1063454.98732458,228.932530450372)) | 36 | zemní práce-sejmutí ornice | Barva_36 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | sejmutí ornice | zemní práce | OTSKP | 12960 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | CZ_M3 - Objem: 50.0716; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-sejmutí ornice | 158.066 | 1 | no | ((-639825.147986876,-1063457.15546111,228.449494280312),(-639810.337857865,-1063449.80600768,229)) | 36 | zemní práce-sejmutí ornice | Barva_36 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | sejmutí ornice | zemní práce | OTSKP | 12110 | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 125;75;0 | P100 | CZ_M3 - Objem: 28.6507; Způsob stanovení objemu: řezová metoda; CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-639819.96629453,-1063469.14403621,228.798425669128),(-639819.828785508,-1063469.00491819,228.900983236086)) | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 191;191;191 | P2 | CZ_I3 - Fáze projektu: PDPS; Název (trasy): nerelevantni; Staničení od: 7.35; Staničení do: 7.49; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení položky: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
vozovka_chodník-geosyntetikum | 86.1307 | 2 | no | ((-639821.552627559,-1063462.20635138,226.904486834347),(-639815.55702877,-1063458.96868365,229.545537260707)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 43.1 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 45.145 | 2 | no | ((-639816.33869959,-1063464.96556991,226.839999999622),(-639814.995598723,-1063456.06338366,229.769999999627)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 22.5 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 4.79287 | 2 | no | ((-639816.33869966,-1063464.96556991,229.769999999622),(-639814.995598724,-1063456.06338366,230.025986238119)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 2.4 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 45.0837 | 2 | no | ((-639821.965923029,-1063464.12268417,226.800000000042),(-639820.622822161,-1063455.22049792,229.730000000047)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 22.5 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 4.79287 | 2 | no | ((-639821.965923029,-1063464.12268417,229.730000000042),(-639820.622822161,-1063455.22049792,229.98598623855)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 2.4 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 2.9986 | 2 | no | ((-639822.461887981,-1063464.1310925,226.799999999814),(-639821.965923027,-1063464.04713553,229.730000000047)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 1.5 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 2.9986 | 2 | no | ((-639816.330291264,-1063465.04952687,226.839999999627),(-639815.834326311,-1063464.96556991,229.76999999986)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 1.5 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 2.9986 | 2 | no | ((-639814.995598724,-1063456.13893229,226.839999999627),(-639814.499633771,-1063456.05497533,229.76999999986)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 1.5 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 2.9986 | 2 | no | ((-639821.127195441,-1063455.22049791,226.799999999814),(-639820.631230487,-1063455.13654095,229.730000000047)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 1.5 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 24.986 | 2 | no | ((-639822.470296376,-1063464.04713552,226.799999999809),(-639821.127195439,-1063455.14494927,229.729999999886)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 12.25 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 24.544 | 2 | no | ((-639815.834326312,-1063465.04111855,226.83999999986),(-639814.491225376,-1063456.13893229,229.769999999922)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 12.25 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 6.847 | 2 | no | ((-639815.871359956,-1063465.33872611,226.839999999855),(-639814.117942948,-1063455.89169049,226.85000000006)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 3.325 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 6.847 | 2 | no | ((-639816.711982086,-1063465.21281171,226.839999999622),(-639814.958565079,-1063455.76577609,226.849999999627)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 3.325 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 6.847 | 2 | no | ((-639822.002956672,-1063464.42029173,226.800000000041),(-639820.249539664,-1063454.97325611,226.810000000246)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 3.325 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 6.847 | 2 | no | ((-639822.843578802,-1063464.29437734,226.799999999808),(-639821.090161795,-1063454.84734172,226.810000000014)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 3.325 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 9.7 | 2 | no | ((-639816.365843562,-1063465.286879,226.839999999855),(-639814.464081473,-1063455.8176232,226.84999999986)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 4.75 | 3D plocha TIN povrchu
vozovka_chodník-geosyntetikum | 9.7 | 2 | no | ((-639822.497440278,-1063464.36844463,226.799999999814),(-639820.595678189,-1063454.89918882,226.810000000246)) | 216 | vozovka_chodník-geosyntetikum | Barva_216 | SO 140 | nerelevantni | PDPS | Rámový propustek | 0 | 0.0147 | geosyntetikum | vozovka/chodník | OTSKP | 21461D | I1+S1+E1+Z1+M2+F1 | geotextilie | ochrana HI | nerelevantni | D.1.10.4 | 127;0;127 | P2 | 4.75 | 3D plocha TIN povrchu
