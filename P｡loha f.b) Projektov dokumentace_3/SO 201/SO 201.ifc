Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: \\10.0.0.20\zakazky\3248-24-3 Přeložka silnice II-322 Černá za Bory - Dašice\PD\STUPEŇ\BIM\2025-03-13-so201.ifc
Time: 2025-07-04T08:40:23
Author: Jan Pidima
Organization: DESKTOP-RS6UGO7
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T02:32:10
Made in: Civil 3D 2025 IfcInfra Plugin v13.7.153.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, Unknown
Classification: Civil 3D

# IfcAnnotation (7)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; Closed: no
Geometry - IsPeriodic: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - Material: ByLayer; CastShadows: no; ReceiveShadows: no
General - Layer: zemní práce-rozprostření ornice (ohumusovani); Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Name | Length | Bounds | IsPlanar | ColorIndex | PlotStyleName
 | 3.16245 | ((-640633.1046590807,-1063784.2389624056,236.1350000014354),(-640631.5176246202,-1063782.3757977053,236.18246760073816)) | no | 256 | ByLayer
 | 0.787257 | ((-640633.3326308229,-1063783.983226786,236.8706082915014),(-640632.9462114444,-1063783.3827405612,236.90495998447295)) | no | 256 | ByLayer
 | 3.32093 | ((-640636.3054462126,-1063796.8478818205,235.98135599374655),(-640634.3046928296,-1063795.0595826323,236.13500000120257)) | no | 73 | Barva_73
 | 0.775456 | ((-640635.9255039793,-1063795.2056353886,237.1074178915875),(-640635.3320268376,-1063794.825847305,237.14495951062767)) | no | 256 | ByLayer
 | 3.80654 | ((-640620.0586363636,-1063801.4308022757,235.3850451032151),(-640618.8068119179,-1063798.2266606719,236.08284588345856)) | no | 256 | ByLayer
 | 0.773219 | ((-640618.7027462334,-1063799.0306069579,237.01776347981655),(-640618.3188150045,-1063798.4426423993,237.06019942877927)) | no | 256 | ByLayer
 | 0.726407 | ((-640619.6516052665,-1063798.3549055874,235.9693398331066),(-640619.1254009332,-1063798.251748585,236.4593747621783)) | yes | 73 | Barva_73

# IfcAnnotation: CogoPoint, IFC Project Base Point
In: UnknownName
Description: IFC Project Base Point; Classification: Standard (Point Styles); Group: _všechny body
C3D_Attributes - PointNumber: 1
Properties - Easting: 0; Elevation: 0; ElevationOverride: 0; FullDescription: IFC Project Base Point; FullDescriptionOverride: IFC Project Base Point; IsCheckedOut: no; IsLabelDragged: no; IsLabelPinned: no; IsLabelVisible: yes; IsLocked: no; IsMovable: yes; IsProjectPoint: no; IsSurveyPoint: no; LabelRotation: 0; MarkerRotation: 0; Northing: 0; PointName: IFC Project Base Point; PointNumber: 1; RawDescription: IFC Project Base Point; RawDescriptionOverride: IFC Project Base Point; ScaleXY: 1; ScaleZ: 1; ShowToolTip: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; Bounds: ((-3.535533905932738,-7.714870395634379,0),(45.98911756688178,6.793997271487039,0)); AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - ColorIndex: 256; Layer: zemní práce-rozprostření ornice (ohumusovani); Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: ByLayer; Visible: yes
Geometry - IsPlanar: no

# IfcBuiltElement (99)
In: UnknownName
Properties - CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; UsesGraphicsCache: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 201; Označení podobjektu: NERELEVANTNÍ; Označení části objektu: NERELEVANTNÍ; Fáze projektu: PDPS; Název stavebního objektu: Most přes Zmínku km 3,191; Klasifikační systém: OTSKP; Označení položky: NERELEVANTNÍ
CZ_E1 - Datum zahájení prací: 01.03.2026; Datum dokončení: 30.10.2026; Doba trvání: 243; Datum uvedení do provozu: 24.02.2025; Stavební postup / etapa výstavby: NERELEVANTNÍ
CZ_F1 - Fáze: NERELEVANTNÍ
Name | Area | IsNull | NumChanges | RecordHistory = ShowHistory | IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení šablony vlastností | Materiál | specifikace | podrobná specifikace | CZ_S1, Reference | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
odvodnění-podkladní beton | 51.7814 | no | 2 | no | yes | ((-640635.985401742,-1063795.4409532521,231.93499999999997),(-640629.8629343398,-1063783.9220364208,232.13499999999996)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 4.49812 | řezová metoda
odvodnění-podkladní beton | 51.7815 | no | 2 | no | yes | ((-640621.8228171503,-1063798.4834755524,231.87999999999997),(-640615.6882181303,-1063787.0423761257,232.07999999999998)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 4.49814 | řezová metoda
nosná konstrukce-nosná konstrukce | 164.993 | no | 2 | yes | yes | ((-640621.5845301839,-1063798.2475415026,232.08),(-640615.9241543089,-1063787.274816584,236.41155857535054)) | 9 | nosná konstrukce-nosná konstrukce | Barva_9 | 3.18 | 3.21 | nosná konstrukce | nosná konstrukce | I1+S1;4+E1+Z1+M3+F1 | ŽELEZOBETON | C30/37-XC4, XF3, XD1 (CZ F.1.2) – Cl 0,40; Dmax 22 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P1 | 54.5165 | řezová metoda | CZ_S4 - Beton: C30/37-XC4, XF3, XD1 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206 a TKP 18; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.18; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.4.X.; Návrhová životnost: 100 let
nosná konstrukce-nosná konstrukce | 165.367 | no | 2 | yes | yes | ((-640635.7455720521,-1063795.201588916,232.13499999999996),(-640630.0620499004,-1063784.1619566286,236.4838063258623)) | 9 | nosná konstrukce-nosná konstrukce | Barva_9 | 3.18 | 3.21 | nosná konstrukce | nosná konstrukce | I1+S1;4+E1+Z1+M3+F1 | ŽELEZOBETON | C30/37-XC4, XF3, XD1 (CZ F.1.2) – Cl 0,40; Dmax 22 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P1 | 54.6284 | řezová metoda | CZ_S4 - Beton: C30/37-XC4, XF3, XD1 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206 a TKP 18; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.18; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.4.X.; Návrhová životnost: 100 let
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640633.0123407913,-1063794.7105312769,226.685),(-640632.3123407913,-1063794.0105312767,232.185)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640632.533870939,-1063792.5119938997,226.685),(-640631.8338709391,-1063791.8119938995,232.185)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640632.0553822853,-1063790.3133701314,226.685),(-640631.3553822853,-1063789.6133701312,232.185)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640621.2871071743,-1063797.2623997123,226.63499999999996),(-640620.5871071743,-1063796.5623997122,232.13499999999996)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640631.576912433,-1063788.1148327542,226.685),(-640630.8769124331,-1063787.414832754,232.185)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640631.0984237792,-1063785.916208986,226.685),(-640630.3984237793,-1063785.2162089858,232.185)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640620.808637322,-1063795.0638623352,226.63499999999996),(-640620.1086373221,-1063794.363862335,232.13499999999996)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640620.3301486683,-1063792.8652385669,226.63499999999996),(-640619.6301486683,-1063792.1652385667,232.13499999999996)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640619.851678816,-1063790.6667011897,226.63499999999996),(-640619.1516788161,-1063789.9667011895,232.13499999999996)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
založení-pilota | 12.8648 | no | 2 | no | yes | ((-640619.3731901622,-1063788.4680774214,226.63499999999996),(-640618.6731901623,-1063787.7680774212,232.13499999999996)) | 6 | založení-pilota | Barva_6 | 3.18 | 3.21 | pilota | založení | I1+S1;4+E1+Z1+M1&3+F1 | C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22 | ČSN EN 1536 - Vrtané piloty A TKP 16 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;0;255 | P10 | 2.11665 | řezová metoda | CZ_S4 - Beton: C35/45-XC4 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2.; D.2.1.3.; ; D.2.1.4.X; Návrhová životnost: 100 let; CZ_M1 - Délka: 0; Způsob stanovení délky: Délka 3D křivky
zemní práce-násyp | 67.6646 | no | 2 | yes | yes | ((-640635.9835118931,-1063794.4256182548,231.93499999999997),(-640631.4747484797,-1063784.5766690064,233.38715317327578)) | 256 | zemní práce-násyp | ByLayer | 3.18 | 3.21 | násyp | zemní práce | I1+S1+E1+Z1+M3+F1 | ZÁSYP ZA OPĚROU | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 0;255;0 | P50 | 20.0218 | řezová metoda
odvodnění-podkladní beton | 26.6971 | no | 2 | yes | yes | ((-640633.4948963937,-1063794.4921290346,232.13500008045975),(-640631.1822106459,-1063785.142475335,233.2827869026426)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 3.04618 | řezová metoda
odvodnění-drenážní potrubí | 5.08035 | no | 2 | yes | yes | ((-640633.3826585541,-1063794.484386065,233.09709478793047),(-640631.0537893656,-1063785.1679934913,233.45300008463855)) | 176 | odvodnění-drenážní potrubí | Barva_176 | 3.18 | 3.21 | drenážní potrubí | odvodnění | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;0;128 | P1 | CZ_M1 - Délka: 1.38; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: DRENÁŽNÍ POTRUBÍ; Stavební výrobek: POTRUBÍ; Specifikace: ČSN 73 6244; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.3.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: DRENÁŽ
odvodnění-drenážní žebro | 15.714 | no | 2 | yes | yes | ((-640633.494869284,-1063794.492129989,233.12478280258176),(-640631.1822064478,-1063785.1424814984,233.58278280258176)) | 216 | odvodnění-drenážní žebro | Barva_216 | 3.18 | 3.21 | drenážní žebro | odvodnění | I1+S1;2+E1+Z1+M3+F1 | MZB 8 | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 0.636372 | řezová metoda | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: NERELEVANTNÍ; Podrobná specifikace: NERELEVANTNÍ; Reference: NERELEVANTNÍ; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: OBETONOVÁNÍ RUBOVÉ DRENÁŽE MEZEROVITÝM BETONEM
odvodnění-podkladní beton | 26.6971 | no | 2 | yes | yes | ((-640633.4948963552,-1063794.4921290446,232.13500008045986),(-640631.1822106459,-1063785.1424753352,233.28278690264304)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 3.04618 | řezová metoda
podpěra-těsnící vrstva | 59.7011 | no | 2 | yes | yes | ((-640636.3101712924,-1063794.4311620288,232.9890398721697),(-640631.4503650473,-1063784.5024004113,233.7221490407704)) | 216 | podpěra-těsnící vrstva | Barva_216 | 3.18 | 3.21 | těsnící vrstva | podpěra | I1+S1+E1+Z1+M3+F1 | ŠTĚRKOPÍSEK | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 7.60344 | řezová metoda
odvodnění-drenážní žebro | 56.4857 | no | 2 | yes | yes | ((-640633.787403918,-1063794.492129998,233.2880635507109),(-640631.1822064479,-1063785.075971439,235.75518262184465)) | 216 | odvodnění-drenážní žebro | Barva_216 | 3.18 | 3.21 | drenážní žebro | odvodnění | I1+S1;2+E1+Z1+M3+F1 | ŠDA | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 12.487 | řezová metoda | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: NERELEVANTNÍ; Podrobná specifikace: NERELEVANTNÍ; Reference: NERELEVANTNÍ; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: OCHRANNÝ OBSYP
podpěra-přechodový klín | 134.955 | no | 2 | yes | yes | ((-640639.1284945705,-1063794.4921290714,235.49936622682847),(-640631.1822105248,-1063783.9146235196,236.61239662552651)) | 8 | podpěra-přechodový klín | Barva_8 | 3.18 | 3.21 | přechodový klín | podpěra |  | ŠDA | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 28.8031 | řezová metoda
podpěra-přechodová deska | 92.7535 | no | 2 | yes | yes | ((-640637.1027944937,-1063794.5475623205,236.03145405112457),(-640630.9383955718,-1063784.322191286,237.0616016882741)) | 9 | podpěra-přechodová deska | Barva_9 | 3.18 | 3.21 | přechodová deska | podpěra | I1+S1;4+E1+Z1+M3+F1 | ŽELEZOBETON | TP 261 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P1 | 14.8721 | řezová metoda | CZ_S4 - Beton: C30/37-XC2, XF2, XD1 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: TP 261 a ČSN 73 6244; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.15; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.4.; Návrhová životnost: 100 let
zemní práce-násyp | 132.859 | no | 2 | yes | yes | ((-640638.4319060277,-1063794.3591090338,233.3220800288265),(-640631.7672794949,-1063784.0743625767,235.89803097111087)) | 3 | zemní práce-násyp | Barva_3 | 3.18 | 3.21 | násyp | zemní práce | I1+S1+E1+Z1+M3+F1 | ZÁSYP ZA OPĚROU | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 0;255;0 | P50 | 72.2678 | řezová metoda
odvodnění-podkladní beton | 81.7064 | no | 2 | yes | yes | ((-640637.2506466426,-1063794.4921290714,235.92382913533464),(-640631.1822105246,-1063784.2885759347,236.46908829820984)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 3.94514 | řezová metoda
odvodnění-podkladní beton | 26.6971 | no | 2 | yes | yes | ((-640620.4992337297,-1063797.3157322872,232.08000008046014),(-640618.1853716068,-1063787.9714324884,233.22778690264346)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 3.04619 | řezová metoda
odvodnění-podkladní beton | 41.2677 | no | 2 | yes | yes | ((-640620.4992338514,-1063798.1005852784,235.98499317366486),(-640615.4246518732,-1063792.613013716,236.4067661665596)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 1.97258 | řezová metoda
zemní práce-násyp | 67.6648 | no | 2 | yes | yes | ((-640620.2055176897,-1063797.8357874476,231.87999999999988),(-640615.6867947052,-1063788.0325667053,233.33215317328066)) | 256 | zemní práce-násyp | ByLayer | 3.18 | 3.21 | násyp | zemní práce | I1+S1+E1+Z1+M3+F1 | ZÁSYP ZA OPĚROU | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 0;255;0 | P50 | 20.0219 | řezová metoda
podpěra-těsnící vrstva | 59.7014 | no | 2 | yes | yes | ((-640620.2300059627,-1063797.9040506755,232.93403987216985),(-640615.358827718,-1063788.027469703,233.66714904077145)) | 216 | podpěra-těsnící vrstva | Barva_216 | 3.18 | 3.21 | těsnící vrstva | podpěra | I1+S1+E1+Z1+M3+F1 | ŠTĚRKOPÍSEK | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 7.60345 | řezová metoda
zemní práce-násyp | 132.659 | no | 2 | yes | yes | ((-640619.9118229742,-1063798.3458992224,233.26708002882663),(-640613.4768773272,-1063788.0936964839,235.83548245135287)) | 3 | zemní práce-násyp | Barva_3 | 3.18 | 3.21 | násyp | zemní práce | I1+S1+E1+Z1+M3+F1 | ZÁSYP ZA OPĚROU | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 0;255;0 | P50 | 72.0976 | řezová metoda
podpěra-přechodový klín | 132.751 | no | 2 | yes | yes | ((-640620.4992338514,-1063798.4770145724,235.43619546667884),(-640612.8385491765,-1063787.9714324637,236.48895384226773)) | 8 | podpěra-přechodový klín | Barva_8 | 3.18 | 3.21 | přechodový klín | podpěra | I1+S1+E1+Z1+M3+F1 | ŠDA | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 27.6839 | řezová metoda
odvodnění-podkladní beton | 41.2698 | no | 2 | yes | yes | ((-640619.4891682018,-1063793.459004363,235.86065837518512),(-640614.4145878437,-1063787.9714324633,236.2924305792509)) | 9 | odvodnění-podkladní beton | Barva_9 | 3.18 | 3.21 | podkladní beton | odvodnění | I1+S1+E1+Z1+M3+F1 | C 8/10 | TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 1.97258 | řezová metoda
podpěra-přechodová deska | 92.716 | no | 2 | yes | yes | ((-640620.7440247443,-1063798.0696880694,235.96828329097482),(-640614.5630318137,-1063787.9204815528,236.99803566776887)) | 9 | podpěra-přechodová deska | Barva_9 | 3.18 | 3.21 | přechodová deska | podpěra | I1+S1;4+E1+Z1+M3+F1 | ŽELEZOBETON | TP 261 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P1 | 14.7895 | řezová metoda | CZ_S4 - Beton: C30/37-XC2, XF2, XD1 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: TP 261 a ČSN 73 6244; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.15; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.4.; Návrhová životnost: 100 let
odvodnění-drenážní žebro | 56.403 | no | 2 | yes | yes | ((-640620.4992379444,-1063797.3768586705,233.23306355071102),(-640617.8916932038,-1063787.971431611,235.69286049025877)) | 216 | odvodnění-drenážní žebro | Barva_216 | 3.18 | 3.21 | drenážní žebro | odvodnění | I1+S1;2+E1+Z1+M3+F1 | ŠDA | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 12.465 | řezová metoda | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: NERELEVANTNÍ; Podrobná specifikace: NERELEVANTNÍ; Reference: NERELEVANTNÍ; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: OCHRANNÝ OBSYP
odvodnění-drenážní žebro | 15.714 | no | 2 | yes | yes | ((-640620.4992379439,-1063797.315726621,233.06978280258215),(-640618.1853988257,-1063787.9714316118,233.5277828025825)) | 216 | odvodnění-drenážní žebro | Barva_216 | 3.18 | 3.21 | drenážní žebro | odvodnění | I1+S1;2+E1+Z1+M3+F1 | MZB 8 | ČSN 73 6244 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 0.636384 | řezová metoda | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: NERELEVANTNÍ; Podrobná specifikace: NERELEVANTNÍ; Reference: NERELEVANTNÍ; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: OBETONOVÁNÍ RUBOVÉ DRENÁŽE MEZEROVITÝM BETONEM
odvodnění-drenážní potrubí | 5.07959 | no | 2 | yes | yes | ((-640620.6268213874,-1063797.2922775312,233.10500008463896),(-640618.2980587105,-1063787.9785493603,233.39800008463916)) | 176 | odvodnění-drenážní potrubí | Barva_176 | 3.18 | 3.21 | drenážní potrubí | odvodnění | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;0;128 | P1 | CZ_M1 - Délka: 1.38; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: DRENÁŽNÍ POTRUBÍ; Stavební výrobek: POTRUBÍ; Specifikace: ČSN 73 6244; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.3.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: DRENÁŽ
záchytné systémy-svodidlo | 52.957 | no | 1 | no | no | ((-640640.7523648922,-1063799.2990806475,235.67727649897387),(-640610.946903672,-1063783.133977577,238.50095924771398)) | 4 | záchytné systémy-svodidlo | Barva_4 | 3.18 | 3.21 | svodidlo | záchytné systémy | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;255;255 | P2 | CZ_M1 - Délka: 28.29; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: ZÁBRADELNÍ SVODIDLO H2; Stavební výrobek: SVODIDLO; Specifikace: TKP 11, TP 114; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2. A D.2.1.3.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: ZÁBRADELNÍ SVODIDLO
úpravy kolem podpěr-práh | 20.7805 | no | 2 | yes | yes | ((-640630.4546324535,-1063797.4076752102,230.35850198181237),(-640623.4920671514,-1063795.4277214326,232.68211615934197)) | 9 | úpravy kolem podpěr-práh | Barva_9 | 3.18 | 3.21 | práh | úpravy kolem podpěr | I1+S1+E1+Z1+M3+F1 | C30/37-XC4, XF4 | VL4 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 3.06975 | řezová metoda
úpravy kolem podpěr-práh | 20.7805 | no | 2 | yes | yes | ((-640628.2019141378,-1063787.049815487,230.31851392025254),(-640621.2393488357,-1063785.0698617094,232.64212809778215)) | 9 | úpravy kolem podpěr-práh | Barva_9 | 3.18 | 3.21 | práh | úpravy kolem podpěr | I1+S1+E1+Z1+M3+F1 | C30/37-XC4, XF4 | VL4 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P10 | 3.06975 | řezová metoda
založení-štěrkopískový polštář | 122.145 | no | 2 | yes | yes | ((-640622.9917248602,-1063809.3170259942,231.27999986059734),(-640614.8510131771,-1063797.3305393218,231.88000001235247)) | 256 | založení-štěrkopískový polštář | ByLayer | 3.18 | 3.21 | štěrkopískový polštář | založení | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 191;191;191 | P100 | 31.2261 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: ŠD; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: VRSTVA ZE ŠTĚRKODRTI 0-63
založení-štěrkopískový polštář | 121.732 | no | 2 | yes | yes | ((-640620.3159618439,-1063788.1508466424,231.2799998769221),(-640608.998480278,-1063777.2738819313,231.88000001234383)) | 256 | založení-štěrkopískový polštář | ByLayer | 3.18 | 3.21 | štěrkopískový polštář | založení | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 191;191;191 | P100 | 31.1306 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: ŠD; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: VRSTVA ZE ŠTĚRKODRTI 0-63
založení-štěrkopískový polštář | 100.054 | no | 2 | yes | yes | ((-640641.3366015524,-1063803.7342687196,231.3349999999769),(-640631.3776545853,-1063794.2403715616,231.93500000162086)) | 256 | založení-štěrkopískový polštář | ByLayer | 3.18 | 3.21 | štěrkopískový polštář | založení | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 191;191;191 | P100 | 25.6132 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: ŠD; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: VRSTVA ZE ŠTĚRKODRTI 0-63
založení-štěrkopískový polštář | 99.5939 | no | 2 | yes | yes | ((-640636.23383889,-1063785.1585789504,231.33499999999216),(-640628.6940740888,-1063775.0704933263,231.93500000224907)) | 256 | založení-štěrkopískový polštář | ByLayer | 3.18 | 3.21 | štěrkopískový polštář | založení | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 191;191;191 | P100 | 25.5057 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: ŠD; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: VRSTVA ZE ŠTĚRKODRTI 0-63
založení-štěrkopískový polštář | 122.364 | no | 2 | yes | yes | ((-640637.0652931506,-1063796.5207044089,231.33499999999998),(-640628.7945798036,-1063782.8329669312,231.93499999999997)) | 9 | založení-štěrkopískový polštář | Barva_9 | 3.18 | 3.21 | štěrkopískový polštář | založení | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 191;191;191 | P100 | 26.6856 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: ŠD; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: VRSTVA ZE ŠTĚRKODRTI 0-63
založení-štěrkopískový polštář | 122.306 | no | 2 | yes | yes | ((-640622.8956132693,-1063799.5474871693,231.27999999999997),(-640614.6269834294,-1063785.9808412115,231.87999999999997)) | 9 | založení-štěrkopískový polštář | Barva_9 | 3.18 | 3.21 | štěrkopískový polštář | založení | I1+S3+E1+Z1+M3+F1 |  |  |  |  | 191;191;191 | P100 | 26.6707 | řezová metoda | CZ_S3 - Klasifikace zemin / hornin: ŠD; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: VRSTVA ZE ŠTĚRKODRTI 0-63
záchytné systémy-zábradlí | 34.7902 | no | 2 | yes | yes | ((-640637.5102255275,-1063804.8342995262,233.19216028011542),(-640614.2521752911,-1063777.5433494535,237.27787016084412)) | 4 | záchytné systémy-zábradlí | Barva_4 | 3.18 | 3.21 | zábradlí | záchytné systémy | I1+S2+E1+Z1+M1;5+F1 |  |  |  |  | 0;255;255 | P2 | CZ_M1 - Délka: 24; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: TKP 11 a ČSN 73 6101; Podrobná specifikace: OCELOVÉ DVOUMADLOVÉ ZÁBRADLÍ; Reference: D.2.1.2.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: ZÁBRADLÍ; CZ_M5 - Hmotnost: 0; Způsob stanovení hmotnosti: data ze statického posouzení
vozovka_chodník-spodní podkladní vrstva | 178.705 | no | 2 | yes | yes | ((-640641.1561120466,-1063795.9414288178,236.27076004940855),(-640630.9386386079,-1063781.8544510438,236.85512484558788)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | 3.18 | 3.21 | spodní podkladní vrstva | vozovka/chodník | I1+S1+E1+Z1+M3;2&6+F1 | ŠDB | ČSN 73 6126-1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P2 | 22.7715 | řezová metoda | CZ_M6 - Tloušťka: 0.25
zemní práce-zemní krajnice a dosypávky | 40.9262 | no | 2 | yes | yes | ((-640641.1013810168,-1063795.6943319512,236.42655732007665),(-640632.3371925025,-1063782.0837041824,237.06014647637141)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | 3.18 | 3.21 | zemní krajnice a dosypávky | zemní práce | I1+S1+E1+Z1+M3+F1 | NENAMRZAVÝ MATERIÁL | VL 1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 3.35 | řezová metoda
zemní práce-rozprostření ornice (ohumusovani) | 5.29964 | no | 2 | yes | yes | ((-640638.0873228373,-1063800.0449493332,234.66841452390403),(-640634.8266530447,-1063796.2803062121,236.1318707761759)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.389058 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 5.69623 | no | 2 | yes | yes | ((-640633.6842271135,-1063782.5736193322,234.76675414241325),(-640631.7020854764,-1063778.92502647,236.18246760114562)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.416866 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-zemní krajnice a dosypávky | 23.7122 | no | 2 | yes | yes | ((-640616.8471355857,-1063790.1026261563,236.2255616444606),(-640609.1972740163,-1063786.6374964064,236.71856919215784)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | 3.18 | 3.21 | zemní krajnice a dosypávky | zemní práce | I1+S1+E1+Z1+M3+F1 |  |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P100 | 1.84882 | řezová metoda
vozovka_chodník-přídlažba | 7.38221 | no | 2 | no | yes | ((-640615.994745914,-1063789.195265604,236.56735789185407),(-640611.5727758323,-1063787.7902623583,237.0304666473464)) | 5 | vozovka_chodník-přídlažba | Barva_5 | 3.18 | 3.21 | přídlažba | vozovka/chodník | I1+S2+E1+Z1+M2+F1 |  |  |  |  | 0;0;255 | P2 | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: VL4; Podrobná specifikace: BETONOVÁ DLAŽBA DO BETONOVÉHO LOŽE; Reference: D.2.1.2.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: BETONOVÁ DLAŽBA; CZ_M2 - Plocha: 3.55309; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-obrubník | 3.22079 | no | 2 | yes | yes | ((-640615.8869892501,-1063788.6753188684,236.56691212705843),(-640611.4551927982,-1063787.6922004067,236.9697121987621)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 4.54; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 3.69605 | no | 2 | yes | yes | ((-640616.0241340712,-1063789.361752961,236.6307215154363),(-640611.5825415668,-1063788.3296035242,237.03354905695542)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 4.53; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 2.07841 | no | 2 | yes | yes | ((-640618.087154918,-1063798.400261138,236.87926768894005),(-640615.6066235771,-1063797.7576446189,237.27173272386793)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 2.48; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-přídlažba | 4.13963 | no | 2 | no | yes | ((-640618.1977629339,-1063798.9193808087,236.81849888472138),(-640615.7346433306,-1063797.904580454,237.26873272386777)) | 5 | vozovka_chodník-přídlažba | Barva_5 | 3.18 | 3.21 | přídlažba | vozovka/chodník | I1+S2+E1+Z1+M2+F1 |  |  |  |  | 0;0;255 | P2 | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: VL4; Podrobná specifikace: BETONOVÁ DLAŽBA DO BETONOVÉHO LOŽE; Reference: D.2.1.2.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: BETONOVÁ DLAŽBA; CZ_M2 - Plocha: 1.33215; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-obrubník | 1.80081 | no | 2 | yes | yes | ((-640618.2178721913,-1063799.0370176735,236.81581541868582),(-640615.7473954794,-1063798.4433797654,237.20828045366764)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 2.48; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 1.80055 | no | 2 | yes | yes | ((-640638.2523041615,-1063794.7139960374,236.93043065572078),(-640635.7943418301,-1063794.0499915532,237.29796562091303)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 2.48; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-přídlažba | 4.1357 | no | 2 | no | yes | ((-640638.1320256288,-1063794.6166859146,236.93213498209244),(-640635.6676258289,-1063793.537601202,237.35841789148597)) | 5 | vozovka_chodník-přídlažba | Barva_5 | 3.18 | 3.21 | přídlažba | vozovka/chodník | I1+S2+E1+Z1+M2+F1 |  |  |  |  | 0;0;255 | P2 | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: VL4; Podrobná specifikace: BETONOVÁ DLAŽBA DO BETONOVÉHO LOŽE; Reference: D.2.1.2.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: BETONOVÁ DLAŽBA; CZ_M2 - Plocha: 1.33031; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-obrubník | 2.07582 | no | 2 | yes | yes | ((-640638.1025503662,-1063794.081445888,236.99388292641572),(-640635.6330691376,-1063793.368786343,237.36141789158773)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 2.48; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 2.07583 | no | 2 | yes | yes | ((-640636.060053105,-1063784.6491203348,236.75722346357796),(-640633.5914800876,-1063783.9357534444,237.12458810482056)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 2.52; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-přídlažba | 4.13573 | no | 2 | no | yes | ((-640635.929003346,-1063784.5029712233,236.6954684039993),(-640633.4676474957,-1063783.4225267884,237.1215881048207)) | 5 | vozovka_chodník-přídlažba | Barva_5 | 3.18 | 3.21 | přídlažba | vozovka/chodník | I1+S2+E1+Z1+M2+F1 |  |  |  |  | 0;0;255 | P2 | CZ_S2 - Typ stavebního výrobku: NERELEVANTNÍ; Stavební výrobek: NERELEVANTNÍ; Specifikace: VL4; Podrobná specifikace: BETONOVÁ DLAŽBA DO BETONOVÉHO LOŽE; Reference: D.2.1.2.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: BETONOVÁ DLAŽBA; CZ_M2 - Plocha: 1.33033; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-obrubník | 1.80055 | no | 2 | yes | yes | ((-640635.9024501549,-1063783.9670567526,236.69377119555244),(-640633.4451339233,-1063783.3024062319,237.0611358365857)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 2.52; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 0.435673 | no | 2 | yes | yes | ((-640611.6834009475,-1063789.215213738,236.5612730106573),(-640611.4719350914,-1063788.655470632,236.88073229202752)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 0.11; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 0.435673 | no | 2 | yes | yes | ((-640615.845193561,-1063798.938663503,236.81581541870213),(-640615.6367059766,-1063798.380184551,237.1349511547747)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 0.1; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 0.435673 | no | 2 | yes | yes | ((-640638.2298565282,-1063794.0759145524,236.92474718986279),(-640638.0047148187,-1063793.511434568,237.2438829264904)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 0.1; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-obrubník | 0.435673 | no | 2 | yes | yes | ((-640636.0274206157,-1063783.9607199668,236.69320815231796),(-640635.8045473817,-1063783.3967492692,237.01292625882573)) | 40 | vozovka_chodník-obrubník | Barva_40 | 3.18 | 3.21 | obrubník | vozovka/chodník | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 255;165;0 | P2 | CZ_M1 - Délka: 0.1; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: PREFABRIKOVANÝ; Stavební výrobek: OBRUBNÍK SILNIČNÍ; Specifikace: C30/37-XF4,XC4; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NERELEVATNÍ; Kategorie stavebního výrobku: OBRUBNÍK
vozovka_chodník-spodní podkladní vrstva | 221.335 | no | 2 | yes | yes | ((-640619.5544242384,-1063800.69096045,236.01131065203913),(-640609.1173397255,-1063786.2921120755,236.75935479339634)) | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | 3.18 | 3.21 | spodní podkladní vrstva | vozovka/chodník | I1+S1+E1+Z1+M3;2&6+F1 | ŠDB | ČSN 73 6126-1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P2 | 22.7715 | řezová metoda | CZ_M6 - Tloušťka: 0
zemní práce-zemní krajnice a dosypávky | 51.8154 | no | 2 | yes | yes | ((-640619.1791118688,-1063800.4595729203,236.2255616444606),(-640609.1621983725,-1063786.6374964064,236.95675435465108)) | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | 3.18 | 3.21 | zemní krajnice a dosypávky | zemní práce | I1+S1+E1+Z1+M3+F1 | NENAMRZAVÝ MATERIÁL | VL 1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 4.26279 | řezová metoda
odvodnění-zpevněné příkopy a odvodňovací žlaby | 12.6436 | no | 2 | yes | yes | ((-640610.6153029178,-1063779.4924795886,231.785),(-640608.6398350307,-1063776.949356996,232.635)) | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 | 3.18 | 3.21 | zpevněné příkopy a odvodňovací žlaby | odvodnění | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 128;128;128 | P10 | CZ_M1 - Délka: 1.68; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: MONILITICKÉ; Stavební výrobek: VÝVAŘIŠTĚ S VSAKOVACÍ FUNKCÍ; Specifikace: VL 4 – 504.82; Podrobná specifikace: VÝVAŘIŠTĚ S VSAKOVACÍ FUNKCÍ; Reference: D.2.1.2.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: VÝVAŘIŠTĚ
odvodnění-zpevněné příkopy a odvodňovací žlaby | 14.6071 | no | 2 | yes | yes | ((-640612.1197276348,-1063788.5701223083,232.52211124787127),(-640609.7172084576,-1063779.268539878,236.79894293790124)) | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 | 3.18 | 3.21 | zpevněné příkopy a odvodňovací žlaby | odvodnění | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 128;128;128 | P10 | CZ_M1 - Délka: 0.61; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: NRELEVANTNÍ; Stavební výrobek: ŽLABOVKA; Specifikace: ŽLABOVKY DO BETONOVÉHO LOŽE; Podrobná specifikace: NRELEVANTNÍ; Reference: D.2.1.2.; Výrobce: NRELEVANTNÍ; Kategorie stavebního výrobku: ODVODŃOVACÍ ŽLAB
zemní práce-rozprostření ornice (ohumusovani) | 148.078 | no | 2 | no | yes | ((-640616.4376436326,-1063790.2805525172,232.15786107414243),(-640607.3987917831,-1063778.2207795999,236.88354763839442)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 10.3806 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 13.9641 | no | 2 | yes | yes | ((-640636.2894454466,-1063774.809599487,232.9834568531284),(-640629.9093736185,-1063772.7671885728,233.2026847166995)) | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.889305 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 169.96 | no | 2 | yes | yes | ((-640619.8795973116,-1063810.1136759515,231.99726313258236),(-640611.1355851168,-1063797.8618671286,237.10926769128358)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 12.6564 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 116.303 | no | 2 | yes | yes | ((-640643.115042865,-1063804.1028256041,232.83147839539683),(-640635.0720710575,-1063792.2477029408,237.22512484558789)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 8.63479 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 102.199 | no | 2 | yes | yes | ((-640638.660102009,-1063784.6491203357,232.9720291315421),(-640631.6943678315,-1063774.0433481561,237.0126248455955)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE | NERELEVANTNÍ | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 7.61343 | řezová metoda | CZ_M6 - Tloušťka: 0.15
nosná konstrukce-nosná konstrukce | 313.284 | no | 2 | yes | yes | ((-640635.7455277084,-1063798.2475352231,236.13104754592632),(-640615.9241547083,-1063784.161958574,237.1040429791662)) | 9 | nosná konstrukce-nosná konstrukce | Barva_9 | 3185.09 | 3203.22 | nosná konstrukce | nosná konstrukce |  |  |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 191;191;191 | P1 | 68.9577 | řezová metoda | CZ_S4 - Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Množství předpínací výztuže: 0
odvodnění-drenážní žebro | 4.84912 | no | 2 | no | yes | ((-640630.9707019035,-1063788.430378752,236.75338307877848),(-640616.2519329672,-1063785.264470507,236.86660403301067)) | 216 | odvodnění-drenážní žebro | Barva_216 | 3187.86 | 3202.99 | drenážní žebro | odvodnění | I1+S1;2+E1+Z1+M3+F1 | POLYMERNÍ BETON | VL 4 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 127;0;127 | P1 | 0.0720042 | řezová metoda | CZ_S2 - Typ stavebního výrobku: POLYMERNÍ BETON; Stavební výrobek: NERELEVANTNÍ; Specifikace: VL 4; Podrobná specifikace: NERELEVANTNÍ; Reference: NERELEVANTNÍ; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: DRENÁŽNÍ POLYMERBETON
2 x římsa-římsa | 58.3918 | no | 1 | no | no | ((-640633.6241230672,-1063788.4769680062,236.2477444655126),(-640615.8630776436,-1063783.8699062986,237.15878494173194)) | 40 | římsa-římsa | Barva_40 | 3185.09 | 3203.22 | římsa | římsa | I1+S1;4+E1+Z1+M3+F1 | ŽELEZOBETON | ČSN EN 206 A TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;165;0 | P1 | 6.82981 | řezová metoda | CZ_S4 - Beton: C30/37-XC4, XF4, XD3 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206 A TKP 18; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2. a D.2.1.3; Návrhová životnost: 25 let
římsa-chránička | 6.20358 | no | 2 | yes | yes | ((-640635.7905111472,-1063798.4486387633,236.5819292996348),(-640618.1748646749,-1063794.515405967,236.7816144710357)) | 216 | římsa-chránička | Barva_216 | 3185.22 | 3203.09 | chránička | římsa | I1+S3+E1+Z1+M1+F1 |  |  |  |  | 127;0;127 | P10 | CZ_M1 - Délka: 17.87; Způsob stanovení délky: Délka 3D křivky; CZ_S3 - Klasifikace zemin / hornin: NERELEVANTNÍ; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: NERELEVANTNÍ
římsa-chránička | 6.20358 | no | 2 | yes | yes | ((-640635.7905111472,-1063798.4486387633,236.7719292996348),(-640618.1748646749,-1063794.515405967,236.9716144710357)) | 216 | římsa-chránička | Barva_216 | 3185.22 | 3203.09 | chránička | římsa | I1+S3+E1+Z1+M1+F1 |  |  |  |  | 127;0;127 | P10 | CZ_M1 - Délka: 17.87; Způsob stanovení délky: Délka 3D křivky; CZ_S3 - Klasifikace zemin / hornin: NERELEVANTNÍ; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: NERELEVANTNÍ
římsa-chránička | 6.20358 | no | 2 | yes | yes | ((-640635.7905111472,-1063798.4486387633,236.9619292996348),(-640618.1748646749,-1063794.515405967,237.1616144710357)) | 216 | římsa-chránička | Barva_216 | 3185.22 | 3203.09 | chránička | římsa | I1+S3+E1+Z1+M1+F1 |  |  |  |  | 127;0;127 | P10 | CZ_M1 - Délka: 17.87; Způsob stanovení délky: Délka 3D křivky; CZ_S3 - Klasifikace zemin / hornin: NERELEVANTNÍ; Třída těžitelnosti: NERELEVANTNÍ; Další specifikace: NERELEVANTNÍ
římsa-římsa | 76.8928 | no | 2 | yes | yes | ((-640635.8120299273,-1063798.541733796,236.4859118268848),(-640618.0558326087,-1063793.9354871206,237.39576179264324)) | 40 | římsa-římsa | Barva_40 | 3185.22 | 3203.09 | římsa | římsa | I1+S1;4+E1+Z1+M3+F1 | ŽELEZOBETON | ČSN EN 206 A TKP 18 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 255;165;0 | P1 | 6.36256 | řezová metoda | CZ_S4 - Beton: C30/37-XC4, XF4, XD3 (CZ F.1.2) – Cl 0,40; Dmax 22; Specifikace: ČSN EN 206 A TKP 18; Typ betonářské vyztuže: B500B; Množství betonářské výztuže na m3: 0.13; Množství betonářské výztuže: 0; Typ předpínací vyztuže: NERELEVANTNÍ; Množství předpínací výztuže: 0; Referencované výkresy: D.2.1.2. a D.2.1.3; Návrhová životnost: 25 let
zemní práce-úpravy svahů | 168.742 | no | 2 | yes | yes | ((-640630.3094462478,-1063796.9123183673,230.72242520026074),(-640621.3779053388,-1063785.5675267328,232.6842510488616)) | 8 | zemní práce-úpravy svahů | Barva_8 | 3190.66 | 3197.65 | úpravy svahů | zemní práce |  | Kamená dlažba do betonového lože | VL 4 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 30.9082 | řezová metoda | CZ_M6 - Tloušťka: 0
zemní práce-úpravy svahů | 22.2216 | no | 2 | yes | yes | ((-640628.0566652231,-1063786.554463761,230.71944455481614),(-640621.0591124644,-1063784.1015063848,232.64426299092156)) | 8 | zemní práce-úpravy svahů | Barva_8 | 3190.65 | 3197.66 | úpravy svahů | zemní práce |  | Kamená dlažba do betonového lože | VL 4 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 3.06022 | řezová metoda | CZ_M6 - Tloušťka: 0
zemní práce-úpravy svahů | 22.2216 | no | 2 | yes | yes | ((-640630.6294479085,-1063798.3777793297,230.76022396180988),(-640623.6318951498,-1063795.9248219535,232.6850423979153)) | 8 | zemní práce-úpravy svahů | Barva_8 | 3190.71 | 3197.6 | úpravy svahů | zemní práce |  | Kamená dlažba do betonového lože | VL 4 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P10 | 3.06022 | řezová metoda | CZ_M6 - Tloušťka: 0
vozovka-podkladní asfaltová vrstva | 335.426 | no | 2 | yes | yes | ((-640640.6759688673,-1063798.8081038948,236.68834719351884),(-640609.4812818863,-1063783.7993020182,237.12732005051203)) | 8 | vozovka-podkladní asfaltová vrstva | Barva_8 | 3180 | 3210 | podkladní asfaltová vrstva | vozovka | I1+S1+E1+Z1+M3;2&6+F1 | ACP 16+ | ČSN EN 13108-1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P2 | 11.354 | řezová metoda | CZ_M6 - Tloušťka: 0.07
vozovka-obrusná vrstva | 562.901 | no | 1 | no | no | ((-640640.6374630745,-1063798.6453121416,236.82249276313908),(-640609.5128420047,-1063783.960592129,237.22732005051202)) | 8 | vozovka-obrusná vrstva | Barva_8 | 3180 | 3210 | obrusná vrstva | vozovka | I1+S1+E1+Z1+M3;2&6+F1 | ACO 11+ | ČSN EN 13108-1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P2 | 11.1896 | řezová metoda | CZ_M6 - Tloušťka: 0.04
vozovka-horní podkladní vrstva | 350.1 | no | 2 | yes | yes | ((-640640.7715672185,-1063799.2122670626,236.47805498572663),(-640609.4029275648,-1063783.3988669782,237.057320050512)) | 8 | vozovka-horní podkladní vrstva | Barva_8 | 3180 | 3210 | horní podkladní vrstva | vozovka | I1+S1+E1+Z1+M3;2&6+F1 | MZK | ČSN 73 6126-1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P2 | 31.2878 | řezová metoda | CZ_M6 - Tloušťka: 0.2
vozovka-ložní vrstva | 568.173 | no | 1 | no | no | ((-640640.6561280962,-1063798.724222648,236.76048326946818),(-640609.4975437793,-1063783.8824095181,237.187320050512)) | 8 | vozovka-ložní vrstva | Barva_8 | 3180 | 3210 | ložní vrstva | vozovka | I1+S1+E1+Z1+M3;2&6+F1 | ACL 16+ | ČSN EN 13108-1 | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 128;128;128 | P2 | 16.8928 | řezová metoda | CZ_M6 - Tloušťka: 0.06
zemní práce-rozprostření ornice (ohumusovani) | 9.67126 | no | 2 | yes | yes | ((-640617.5041162549,-1063787.8966628422,235.3353957794206),(-640615.2818984177,-1063784.8856801852,236.82207705144197)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.695929 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 6.53669 | no | 2 | yes | yes | ((-640633.36797967,-1063784.5298982575,236.00684169279714),(-640631.5188289325,-1063782.3732101605,236.9104919042588)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.7 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 7.69301 | no | 2 | yes | yes | ((-640636.3640800074,-1063797.310051331,235.8535111740169),(-640634.3021910774,-1063794.7660089235,237.15474426525483)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.708509 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 10.0837 | no | 2 | yes | yes | ((-640620.0674191,-1063801.4334373388,235.25869562675015),(-640618.2850679398,-1063797.9361991403,237.06442164622837)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.708509 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 0.68243 | no | 2 | yes | yes | ((-640634.9292960659,-1063795.057931013,236.13719520725286),(-640634.2575259596,-1063794.6268250726,236.64760766255958)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 0.708509 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-rozprostření ornice (ohumusovani) | 529.702 | no | 2 | yes | yes | ((-640639.0055736905,-1063810.4760465669,232.01050483694758),(-640610.2154730975,-1063774.7354624148,233.55023459803698)) | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | 3.18 | 3.21 | rozprostření ornice (ohumusovani) | zemní práce | I1+S1+E1+Z1+M3;2&6+F1 | ORNICE |  | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 165;207;99 | P100 | 40.0129 | řezová metoda | CZ_M6 - Tloušťka: 0.15
zemní práce-vrstvy vyztužených a sendičových zemních kcí | 618.626 | no | 2 | yes | yes | ((-640641.3158843233,-1063809.0433113328,231.88219506060807),(-640609.2652213098,-1063775.3458588466,236.13719525083187)) | 256 | zemní práce-vrstvy vyztužených a sendičových zemních kcí | ByLayer | 3180.9 | 3208.13 | vrstvy vyztužených a sendičových zemních kcí | zemní práce | I1+S1+E1+Z1+M3+F1 | VYZTUŽENÁ ZEMINA | NERELEVANTNÍ | NERELEVANTNÍ | D.2.1.2 A D.2.1.3. | 0;0;128 | P10 | 399.386 | řezová metoda
 |  |  |  |  | no | ((-640640.7713941778,-1063799.2039513495,237.25863965305632),(-640609.4046314369,-1063783.4061798723,237.9832969133121)) | 4 | záchytné systémy-svodidlo | Barva_4 | 3.18 | 3.21 | svodidlo | záchytné systémy | I1+S2+E1+Z1+M1+F1 |  |  |  |  | 0;255;255 | P10 | CZ_M1 - Délka: 28.29; Způsob stanovení délky: Délka 3D křivky; CZ_S2 - Typ stavebního výrobku: ZÁBRADELNÍ SVODIDLO H2; Stavební výrobek: SVODIDLO; Specifikace: TKP 11, TP 114; Podrobná specifikace: NERELEVANTNÍ; Reference: D.2.1.2. A D.2.1.3.; Výrobce: NERELEVANTNÍ; Kategorie stavebního výrobku: ZÁBRADELNÍ SVODIDLO; Properties - Perimeter: 493.423; UIsoLineDensity: 6; VIsoLineDensity: 6
