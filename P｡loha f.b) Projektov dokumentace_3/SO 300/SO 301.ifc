Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 301.ifc
Time: 2025-03-14T09:42:34
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, Unknown
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (17)
In: UnknownName
Properties - IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_F1 - Fáze: trvalý stav
CZ_I1 - Označení stavebního objektu: SO 301; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka vodovodu; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu | Klasifikace zemin / hornin | Třída těžitelnosti | Další specifikace
trubní vedení-potrubí | 168.025 | 1 | no | ((-642841.812296764,-1062795.12038053,229.000000005588),(-642720.616735682,-1062724.20866231,231.5)) | 4 | trubní vedení-potrubí | Barva_4 | 0 | 178.4 | potrubí | trubní vedení | 85145 | I1+S1+E1+Z1+M1+F1 | 0;255;255 | P10 | CZ_S1 - Materiál: litina; specifikace: LT DN300; podrobná specifikace: nerelevantni; Reference: D.4; CZ_M1 - Délka: 178.4; Způsob stanovení délky: Délka 3D křivky
trubní vedení-podsyp | 446.418 | 1 | no | ((-642841.863053362,-1062795.6602397,228.850000005588),(-642720.200189286,-1062724.15609237,231.2)) | 2 | trubní vedení-podsyp | Barva_2 | 0 | 178.4 | podsyp | trubní vedení | 45157 | I1+S1+E1+Z1+M3+F1 | 255;255;0 | P100 | 29.4281 | objemová metoda | CZ_S1 - Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.4
trubní vedení-obsyp | 607.964 | 1 | no | ((-642841.863053362,-1062795.6602397,229.000000005588),(-642720.200189286,-1062724.15609237,231.8)) | 40 | trubní vedení-obsyp | Barva_40 | 0 | 178.4 | obsyp | trubní vedení | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 255;165;0 | P10 | 117.748 | objemová metoda | CZ_M6 - Tloušťka: 0.6; CZ_S2 - Reference: D.4; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
zemní práce-výkop rýhy | 1003.1 | 1 | no | ((-642841.863053362,-1062795.6602397,228.850000005588),(-642720.200189286,-1062724.15609237,232.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | 0 | 178.4 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | 125;75;0 | P100 | 333.957 | objemová metoda | nerelevantni | 1 | nerelevantni
zemní práce-zásyp rýhy | 733.937 | 1 | no | ((-642841.863053362,-1062795.6602397,229.600000005588),(-642720.200189286,-1062724.15609237,232.75)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 0 | 178.4 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | 0;128;0 | P100 | 186.623 | objemová metoda | fr. 0/63 mm | 1 | nerelevantni
zemní práce-výkop rýhy | 32 | 2 | yes | ((-642843.96743349,-1062748.83764442,230.75),(-642841.602925796,-1062745.60811162,232.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | 0 | 172.91 | výkop rýhy | zemní práce | 131836 | I1+S3+E1+Z1+M3+F1 | 125;75;0 | P100 | 12 | objemová metoda | nerelevantni | 1 | nerelevantni
zemní práce-výkop rýhy | 32 | 2 | yes | ((-642761.058047397,-1062796.53482986,228.55798891489),(-642758.058047397,-1062794.53482986,230.55798891489)) | 36 | zemní práce-výkop rýhy | Barva_36 | 94.29 | 96.88 | výkop rýhy | zemní práce | 131836 | I1+S3+E1+Z1+M3+F1 | 125;75;0 | P100 | 12 | objemová metoda | nerelevantni | 1 | nerelevantni
zemní práce-výkop rýhy | 32 | 2 | yes | ((-642724.279969031,-1062724.42551333,230.150000005588),(-642721.043140906,-1062722.04858648,232.150000005588)) | 36 | zemní práce-výkop rýhy | Barva_36 | 88.18 | 178.4 | výkop rýhy | zemní práce | 131836 | I1+S3+E1+Z1+M3+F1 | 125;75;0 | P100 | 12 | objemová metoda | nerelevantni | 1 | nerelevantni
zemní práce-výkop rýhy | 32 | 2 | yes | ((-642722.301314794,-1062738.79886926,230.141341817481),(-642719.301314794,-1062736.79886926,232.141341817481)) | 36 | zemní práce-výkop rýhy | Barva_36 | 163.08 | 165.9 | výkop rýhy | zemní práce | 131836 | I1+S3+E1+Z1+M3+F1 | 125;75;0 | P100 | 12 | objemová metoda | nerelevantni | 1 | nerelevantni
trubní vedení-chránička | 101.568 | 1 | no | ((-642758.030936153,-1062792.27195992,229.067618543569),(-642739.266895256,-1062764.92552054,230.322269121024)) | 216 | trubní vedení-chránička | Barva_216 | 99 | 131.7 | chránička | trubní vedení | 86657 | I1+S1+E1+Z1+M1+F1 | 127;0;127 | P100 | CZ_S1 - Materiál: ocel; specifikace: DN500; podrobná specifikace: nerelevantni; Reference: D.4; CZ_M1 - Délka: 32.7; Způsob stanovení délky: Délka 3D křivky
trubní vedení-chránička | 34.1725 | 1 | no | ((-642722.726018955,-1062735.55761886,230.600000005588),(-642720.784682431,-1062724.58731894,231.100000005588)) | 216 | trubní vedení-chránička | Barva_216 | 167 | 178 | chránička | trubní vedení | 86657 | I1+S1+E1+Z1+M1+F1 | 127;0;127 | P100 | CZ_S1 - Materiál: ocel; specifikace: DN500; podrobná specifikace: nerelevantni; Reference: D.4; CZ_M1 - Délka: 11; Způsob stanovení délky: Délka 3D křivky
objekty na TV-armatura | 0.462442 | 2 | yes | ((-642722.359149092,-1062724.24040528,230.600000005588),(-642722.279149092,-1062724.16040528,232.400000005588)) | 4 | objekty na TV-armatura | Barva_4 | 178.39 | 178.39 | armatura | objekty na TV | 891226 | I1+S2+E1+Z1+M4+F1 | 0;255;255 | P10 | CZ_S2 - Reference: D.4; Typ stavebního výrobku: ventil; Stavební výrobek: odvzdušňovací souprava DN 80 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-odlučovač | 0.462442 | 2 | yes | ((-642760.466953635,-1062794.91162366,229.01959384543),(-642760.386953635,-1062794.83162366,230.81959384543)) | 4 | objekty na TV-odlučovač | Barva_4 | 95.03 | 95.03 | odlučovač | objekty na TV | 891426 | I1+S2+E1+Z1+M4+F1 | 0;255;255 | P10 | CZ_S2 - Reference: D.4; Typ stavebního výrobku: hydrant podzemní; Stavební výrobek: kalník DN 80 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-642843.96743349,-1062748.83764442,230.75),(-642841.602925796,-1062745.60811162,232.75)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 0 | 1 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | 0;128;0 | P100 | 12 | objemová metoda | fr. 0/63 mm | 1 | nerelevantni
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-642761.058047397,-1062796.53482986,228.55798891489),(-642758.058047397,-1062794.53482986,230.55798891489)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 94.29 | 96.88 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | 0;128;0 | P100 | 12 | objemová metoda | fr. 0/63 mm | 1 | nerelevantni
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-642724.279969031,-1062724.42551333,230.150000005588),(-642721.043140906,-1062722.04858648,232.150000005588)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 177.4 | 178.4 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | 0;128;0 | P100 | 12 | objemová metoda | fr. 0/63 mm | 1 | nerelevantni
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-642722.301314794,-1062738.79886926,230.141341817481),(-642719.301314794,-1062736.79886926,232.141341817481)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 163.08 | 165.9 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | 0;128;0 | P100 | 12 | objemová metoda | fr. 0/63 mm | 1 | nerelevantni
