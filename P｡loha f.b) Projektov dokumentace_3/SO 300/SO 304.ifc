Properties of the parts of a building model (IFC4X3_ADD2), part 3 of 3

# IfcBuiltElement (248)
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Označení stavebního objektu | Označení podobjektu = Označení části objektu = Stavební postup / etapa výstavby | Fáze projektu | Název stavebního objektu | Staničení od | Staničení do | Označení elementu | Skupina elementů | Klasifikační systém | Označení položky | Označení šablony vlastností | Klasifikace zemin / hornin | Třída těžitelnosti | Další specifikace | Datum zahájení prací | Datum dokončení | Doba trvání | Datum uvedení do provozu | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu | Fáze
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639989.739698007,-1063685.42820149,228.97),(-639986.237099412,-1063682.52405468,229.97)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3848.92 | 3851.97 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639989.739698007,-1063685.42820149,228.97),(-639986.237099412,-1063682.52405468,229.97)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3848.92 | 3851.97 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639943.136066281,-1063667.31462896,228.63),(-639939.633467686,-1063664.41048214,229.63)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3898.92 | 3901.97 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639943.136066281,-1063667.31462896,228.63),(-639939.633467686,-1063664.41048214,229.63)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3898.92 | 3901.97 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639896.532434555,-1063649.20105643,228.3),(-639893.02983596,-1063646.29690961,229.3)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3948.92 | 3951.97 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639896.532434555,-1063649.20105643,228.3),(-639893.02983596,-1063646.29690961,229.3)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3948.92 | 3951.97 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639849.928802829,-1063631.08748389,227.95),(-639846.426204234,-1063628.18333707,228.95)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3998.92 | 4001.97 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639849.928802829,-1063631.08748389,227.95),(-639846.426204234,-1063628.18333707,228.95)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3998.92 | 4001.97 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639802.997474854,-1063613.88440321,227.9),(-639799.494876259,-1063610.98025639,228.9)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4049.25 | 4052.29 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639802.997474854,-1063613.88440321,227.9),(-639799.494876259,-1063610.98025639,228.9)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4049.25 | 4052.29 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640006.000932574,-1063691.51790996,229.1),(-640004.700932574,-1063690.21790996,230.7)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3832.23 | 3832.37 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639988.63839871,-1063684.62612808,228.97),(-639987.33839871,-1063683.32612809,230.57)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3850.91 | 3851.05 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639942.034766984,-1063666.51255555,228.63),(-639940.734766984,-1063665.21255555,230.23)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3900.91 | 3901.05 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639895.431135258,-1063648.39898302,228.3),(-639894.131135258,-1063647.09898302,229.9)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3950.91 | 3951.05 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639848.827503531,-1063630.28541048,227.95),(-639847.527503531,-1063628.98541048,229.55)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4000.91 | 4001.05 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639801.896175556,-1063613.0823298,227.9),(-639800.596175556,-1063611.7823298,229.5)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4051.24 | 4051.39 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-výkop rýhy | 459.282 | 1 | no | ((-639598.363260157,-1063539.70985645,227.2),(-639548.467443699,-1063513.28832556,229.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4272.74 | 4316.9 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 227.7 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 35.5 | 2 | yes | ((-639600.22781174,-1063516.34895048,227.2),(-639595.686576203,-1063511.83407575,229.55)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4271.6 | 4275 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 14.1 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 35.5 | 2 | yes | ((-639600.22781174,-1063516.34895048,227.2),(-639595.686576203,-1063511.83407575,229.55)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4271.6 | 4275 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 14.1 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 35.5 | 2 | yes | ((-639551.144127653,-1063541.16410626,227.45),(-639546.602892116,-1063536.64923153,229.8)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4314.63 | 4318.07 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 14.1 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 35.5 | 2 | yes | ((-639551.144127653,-1063541.16410626,227.45),(-639546.602892116,-1063536.64923153,229.8)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4314.63 | 4318.07 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 14.1 | objemová metoda | trvalý stav
objekty na TV-šachta | 29.6252 | 2 | yes | ((-639599.307193971,-1063515.44151312,227.2),(-639596.607193971,-1063512.74151312,229.85)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4274.07 | 4274.6 | šachta | objekty na TV | OTSKP | 89416 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1500; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 29.6252 | 2 | yes | ((-639550.223509884,-1063540.2566689,227.45),(-639547.523509884,-1063537.5566689,230.1)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4317.14 | 4317.69 | šachta | objekty na TV | OTSKP | 89416 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1500; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trubní vedení-potrubí | 139.008 | 1 | no | ((-639598.137667832,-1063539.26364114,227.5),(-639548.693036024,-1063513.73454087,228.55)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4273.05 | 4316.6 | potrubí | trubní vedení | OTSKP | 82460 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 55; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: beton; specifikace: DN 800; podrobná specifikace: nerelevantni
propustky-obetonování | 237.031 | 1 | no | ((-639598.363260157,-1063539.70985645,227.35),(-639548.467443699,-1063513.28832556,227.9)) | 8 | propustky-obetonování | Barva_8 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4272.74 | 4316.9 | obetonování | propustky | OTSKP | 45131A | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 128;128;128 | P50 | 26.1538 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: beton C20/25; specifikace: nerelevantni; podrobná specifikace: nerelevantni
odvodnění-podkladní beton | 215.042 | 1 | no | ((-639598.363260157,-1063539.70985645,227.2),(-639548.467443699,-1063513.28832556,227.6)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4272.74 | 4316.9 | podkladní beton | odvodnění | OTSKP | 451312 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 191;191;191 | P100 | 14.85 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: podkladní beton C12/15; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 369.456 | 1 | no | ((-639598.363260157,-1063539.70985645,227.65),(-639548.467443699,-1063513.28832556,228.85)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4272.74 | 4316.9 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 70.3274 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.95
zemní práce-zásyp rýhy | 1259.37 | 1 | no | ((-641575.643629977,-1063519.6488225,229.800008100003),(-641269.483510822,-1063378.90342739,234.19993328992)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2158.27 | 2485.49 | zásyp rýhy | zemní práce | OTSKP | 17411 | I1+S3+E1+Z1+M3+F1 | zemina | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 251.567 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 220.722 | 1 | no | ((-639598.363260157,-1063539.70985645,228.6),(-639548.467443699,-1063513.28832556,229.05)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4272.74 | 4316.9 | zásyp rýhy | zemní práce | OTSKP | 17411 | I1+S3+E1+Z1+M3+F1 | zemina | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 19.8 | objemová metoda | trvalý stav
