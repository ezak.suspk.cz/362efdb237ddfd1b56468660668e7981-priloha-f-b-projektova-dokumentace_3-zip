Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 3

# IfcBuiltElement (248)
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Označení stavebního objektu | Označení podobjektu = Označení části objektu = Stavební postup / etapa výstavby | Fáze projektu | Název stavebního objektu | Staničení od | Staničení do | Označení elementu | Skupina elementů | Klasifikační systém | Označení položky | Označení šablony vlastností | Klasifikace zemin / hornin | Třída těžitelnosti | Další specifikace | Datum zahájení prací | Datum dokončení | Doba trvání | Datum uvedení do provozu | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu | Fáze
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641050.706550591,-1063598.4921743,240.05),(-641049.406550591,-1063597.1921743,241.65)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2727.1 | 2727.24 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641005.634955698,-1063620.13492038,240.15),(-641004.334955698,-1063618.83492038,241.75)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2777.1 | 2777.23 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640977.187263916,-1063632.17131929,240.25),(-640975.887263916,-1063630.87131929,241.85)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2807.97 | 2808.1 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trubní vedení-potrubí | 202.728 | 1 | no | ((-641270.045385761,-1063631.61558628,233.400017999999),(-640976.503891262,-1063497.38525904,240.900000000005)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2484.9 | 2807.52 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 322.62; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 452.49 | 1 | no | ((-641270.132184182,-1063631.80412027,233.300017999999),(-640976.437145953,-1063497.20507571,240.700000000005)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2484.89 | 2807.54 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 19.3799 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 711.369 | 1 | no | ((-641270.132184182,-1063631.80412027,233.400017999999),(-640976.437145953,-1063497.20507571,241.200000000005)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2484.89 | 2807.54 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 96.8997 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
zemní práce-výkop rýhy | 1890.45 | 1 | no | ((-641575.643629977,-1063519.6488225,228.900008100003),(-641269.483510822,-1063378.90342739,234.19993328992)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2158.27 | 2485.49 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 628.918 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641531.759902643,-1063402.4613657,229),(-641528.195412148,-1063399.37975652,231)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2207 | 2210 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641531.759902643,-1063402.4613657,229),(-641528.195412148,-1063399.37975652,231)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2207 | 2210 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641486.645147864,-1063424.01754387,229.45),(-641483.08065737,-1063420.93593469,231.45)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2257 | 2260 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641486.645147864,-1063424.01754387,229.45),(-641483.08065737,-1063420.93593469,231.45)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2257 | 2260 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641441.48535422,-1063445.47897593,229.9),(-641437.920863725,-1063442.39736675,231.9)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2307 | 2310 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641441.48535422,-1063445.47897593,229.9),(-641437.920863725,-1063442.39736675,231.9)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2307 | 2310 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641396.287384611,-1063466.86009906,230.35),(-641392.722894116,-1063463.77848988,232.35)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2357 | 2360 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641396.287384611,-1063466.86009906,230.35),(-641392.722894116,-1063463.77848988,232.35)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2357 | 2360 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641351.169785249,-1063488.41029423,231.75),(-641347.605294754,-1063485.32868505,233.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2406.99 | 2410 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641351.169785249,-1063488.41029423,231.75),(-641347.605294754,-1063485.32868505,233.75)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2406.99 | 2410 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641306.015123822,-1063509.88252167,232.05),(-641302.450633327,-1063506.8009125,234.05)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2456.99 | 2459.99 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641306.015123822,-1063509.88252167,232.05),(-641302.450633327,-1063506.8009125,234.05)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2456.99 | 2459.99 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641283.645383856,-1063520.40603056,232.2),(-641280.080893362,-1063517.32442139,234.2)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2481.71 | 2484.72 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641283.645383856,-1063520.40603056,232.2),(-641280.080893362,-1063517.32442139,234.2)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2481.71 | 2484.72 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641271.785132714,-1063499.01572131,232.35),(-641268.22064222,-1063495.93411213,234.35)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2483.4 | 2486.4 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 12 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641271.785132714,-1063499.01572131,232.35),(-641268.22064222,-1063495.93411213,234.35)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2483.4 | 2486.4 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 12 | objemová metoda | trvalý stav
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641530.727657396,-1063401.67056111,229),(-641529.227657396,-1063400.17056111,230.75)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2209.04 | 2209.18 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641485.612902617,-1063423.22673928,229.45),(-641484.112902617,-1063421.72673928,231.2)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2259.04 | 2259.18 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641440.453108972,-1063444.68817134,229.9),(-641438.953108972,-1063443.18817134,231.65)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2309.04 | 2309.18 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641395.255139363,-1063466.06929447,230.35),(-641393.755139363,-1063464.56929447,232.1)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2359.04 | 2359.18 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641350.137540001,-1063487.61948964,231.75),(-641348.637540001,-1063486.11948964,233.5)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2409.04 | 2409.17 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641304.982878575,-1063509.09171709,232.05),(-641303.482878575,-1063507.59171709,233.8)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2459.04 | 2459.17 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641282.613138609,-1063519.61522598,232.2),(-641281.113138609,-1063518.11522598,233.95)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2483.76 | 2483.89 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 9.84889 | 2 | yes | ((-641270.752887467,-1063498.22491672,232.35),(-641269.252887467,-1063496.72491672,234.1)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2485.44 | 2485.57 | šachta | objekty na TV | OTSKP | 894157 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: kanalizační DN1000; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trubní vedení-potrubí | 548.367 | 1 | no | ((-641575.493366266,-1063519.19172453,229.000008100003),(-641269.789607032,-1063379.21952993,233.299933289921)) | 256 | trubní vedení-potrubí | ByLayer | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2158.27 | 2483.81 | potrubí | trubní vedení | OTSKP | 81457 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 349.4; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: beton; specifikace: DN 500; podrobná specifikace: nerelevantni
trubní vedení-podsyp | 858.307 | 1 | no | ((-641575.643629977,-1063519.6488225,228.900008100003),(-641278.890885876,-1063378.90342739,232.6828436941)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2158.27 | 2484.16 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 39.6025 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 1321.99 | 1 | no | ((-641575.643629977,-1063519.6488225,229.000008100003),(-641278.890885876,-1063378.90342739,233.4828436941)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2158.27 | 2484.16 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 316.796 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.8
propustky-obetonování | 47.4386 | 1 | no | ((-641279.940358594,-1063514.74200847,232.5328436941),(-641271.617142278,-1063501.04170001,232.923376886744)) | 8 | propustky-obetonování | Barva_8 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2482.96 | 2485.19 | obetonování | propustky | OTSKP | 45131A | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 128;128;128 | P50 | 4.66198 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: beton C20/25; specifikace: nerelevantni; podrobná specifikace: nerelevantni
odvodnění-podkladní beton | 40.8607 | 1 | no | ((-641279.940358594,-1063514.74200847,232.3828436941),(-641271.617142278,-1063501.04170001,232.623376886744)) | 9 | odvodnění-podkladní beton | Barva_9 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2482.96 | 2485.19 | podkladní beton | odvodnění | OTSKP | 451312 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 191;191;191 | P100 | 2.7 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: podkladní beton C12/15; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 64.7353 | 1 | no | ((-641279.940358594,-1063514.74200847,232.8328436941),(-641271.617142278,-1063501.04170001,233.573376886744)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2482.96 | 2485.19 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 9.51933 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.8
trubní vedení-podsyp | 11.6802 | 1 | no | ((-641272.666614996,-1063501.62359949,232.673376886744),(-641269.483510822,-1063497.19363337,232.79993328992)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2483.99 | 2485.49 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 0.528 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 19.5202 | 1 | no | ((-641272.666614996,-1063501.62359949,232.773376886744),(-641269.483510822,-1063497.19363337,233.59993328992)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2483.99 | 2485.49 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 4.224 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.8
zemní práce-výkop rýhy | 1551.27 | 1 | no | ((-640607.208431927,-1063788.4222262,228.9),(-640051.331388416,-1063674.78842695,232.699973140496)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3209.95 | 3794.64 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 258.39 | objemová metoda | trvalý stav
trubní vedení-potrubí | 360.272 | 1 | no | ((-640607.180415672,-1063788.22218232,229),(-640051.407893173,-1063674.97321608,232.249973140496)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3209.96 | 3794.64 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 584.68; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 804.034 | 1 | no | ((-640607.208431927,-1063788.4222262,228.9),(-640051.331388416,-1063674.78842695,232.049973140496)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3209.95 | 3794.64 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 34.4519 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 1263.87 | 1 | no | ((-640607.208431927,-1063788.4222262,229),(-640051.331388416,-1063674.78842695,232.549973140496)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3209.95 | 3794.64 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 172.26 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640608.796939672,-1063779.16278225,231.6),(-640605.537855696,-1063776.74754974,232.6)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3208.38 | 3211.54 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640608.796939672,-1063779.16278225,231.6),(-640605.537855696,-1063776.74754974,232.6)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3208.38 | 3211.54 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640584.895594391,-1063782.63591595,230.95),(-640581.597674159,-1063780.15218174,231.95)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3233.17 | 3236.28 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640584.895594391,-1063782.63591595,230.95),(-640581.597674159,-1063780.15218174,231.95)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3233.17 | 3236.28 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640535.076868031,-1063787.59772534,229.85),(-640531.976239396,-1063785.44335138,230.85)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3284.46 | 3287.6 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640535.076868031,-1063787.59772534,229.85),(-640531.976239396,-1063785.44335138,230.85)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3284.46 | 3287.6 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640485.078113346,-1063789.13595415,228.95),(-640482.044994761,-1063787.0859247,229.95)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3335.83 | 3338.97 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640485.078113346,-1063789.13595415,228.95),(-640482.044994761,-1063787.0859247,229.95)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3335.83 | 3338.97 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640099.752270632,-1063694.83465509,228.58),(-640096.249672038,-1063691.93050827,229.58)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3743.08 | 3746.13 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640099.752270632,-1063694.83465509,228.58),(-640096.249672038,-1063691.93050827,229.58)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3743.08 | 3746.13 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640146.551457871,-1063712.4350476,228.61),(-640143.048859276,-1063709.53090079,229.61)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3693.09 | 3696.14 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640146.551457871,-1063712.4350476,228.61),(-640143.048859276,-1063709.53090079,229.61)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3693.09 | 3696.14 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640193.326010226,-1063730.09827524,228.63),(-640189.823411631,-1063727.19412842,229.63)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3643.09 | 3646.14 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640193.326010226,-1063730.09827524,228.63),(-640189.823411631,-1063727.19412842,229.63)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3643.09 | 3646.14 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640240.232608239,-1063747.3885522,228.66),(-640236.730009645,-1063744.48440538,229.66)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3592.64 | 3595.69 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640240.232608239,-1063747.3885522,228.66),(-640236.730009645,-1063744.48440538,229.66)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3592.64 | 3595.69 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640287.78504698,-1063762.77881492,228.69),(-640284.282448385,-1063759.8746681,229.69)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3541.38 | 3544.59 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640287.78504698,-1063762.77881492,228.69),(-640284.282448385,-1063759.8746681,229.69)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3541.38 | 3544.59 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640336.220058987,-1063774.54093818,228.72),(-640332.919220919,-1063772.05196399,229.72)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3490.04 | 3493.2 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640336.220058987,-1063774.54093818,228.72),(-640332.919220919,-1063772.05196399,229.72)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3490.04 | 3493.2 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640385.465539777,-1063783.06936166,228.75),(-640382.16470171,-1063780.58038748,229.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3438.65 | 3441.81 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640385.465539777,-1063783.06936166,228.75),(-640382.16470171,-1063780.58038748,229.75)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3438.65 | 3441.81 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640435.224482947,-1063786.7276262,228.8),(-640432.062640525,-1063784.47548135,229.8)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3387.26 | 3390.39 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640435.224482947,-1063786.7276262,228.8),(-640432.062640525,-1063784.47548135,229.8)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3387.26 | 3390.39 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
propustky-čelo | 0.375 | 2 | yes | ((-640051.491805192,-1063675.181973,229),(-640051.167761204,-1063674.85792901,229.25)) | 9 | propustky-čelo | Barva_9 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3794.64 | 3794.89 | čelo | propustky | OTSKP | 89516 | I1+S1;4+E1+Z1+M3;4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 191;191;191 | P50 | 0.015625 | objemová metoda | trvalý stav | CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu; CZ_S1 - Reference: D.2; Materiál: beton; specifikace: drenážní výusť; podrobná specifikace: nerelevantni; CZ_S4 - Specifikace: nerelevantni; Beton: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.2; Návrhová životnost: 25
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640607.817397684,-1063778.60516599,231.6),(-640606.517397684,-1063777.30516599,233.2)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3210.46 | 3210.61 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640583.896634275,-1063782.04404884,230.95),(-640582.596634275,-1063780.74404885,232.55)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3235.23 | 3235.38 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640534.176553714,-1063787.17053836,229.85),(-640532.876553714,-1063785.87053836,231.45)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3286.54 | 3286.69 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640484.211554054,-1063788.76093943,228.95),(-640482.911554054,-1063787.46093943,230.55)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3337.92 | 3338.07 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640434.293561736,-1063786.25155378,228.8),(-640432.993561735,-1063784.95155378,230.4)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3389.34 | 3389.49 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640384.465120744,-1063782.47487457,228.75),(-640383.165120744,-1063781.17487457,230.35)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3440.74 | 3440.9 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640335.219639953,-1063773.94645108,228.72),(-640333.919639953,-1063772.64645108,230.32)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3492.12 | 3492.27 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640286.683747682,-1063761.97674151,228.69),(-640285.383747682,-1063760.67674151,230.29)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3543.48 | 3543.63 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640239.131308942,-1063746.58647879,228.66),(-640237.831308942,-1063745.28647879,230.26)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3594.64 | 3594.79 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640192.224710929,-1063729.29620183,228.63),(-640190.924710929,-1063727.99620183,230.23)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3645.08 | 3645.22 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640145.450158573,-1063711.63297419,228.61),(-640144.150158573,-1063710.33297419,230.21)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3695.08 | 3695.22 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640098.650971335,-1063694.03258168,228.58),(-640097.350971335,-1063692.73258168,230.18)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3745.07 | 3745.21 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640046.650109527,-1063673.87314859,228.82),(-640043.147510932,-1063670.96900177,229.82)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3800.17 | 3803.22 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640046.650109527,-1063673.87314859,228.82),(-640043.147510932,-1063670.96900177,229.82)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3800.17 | 3803.22 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640030.232260151,-1063667.48725649,228.75),(-640026.729661556,-1063664.58310968,229.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3817.79 | 3820.84 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640030.232260151,-1063667.48725649,228.75),(-640026.729661556,-1063664.58310968,229.75)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3817.79 | 3820.84 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639983.657756804,-1063649.29891853,228.55),(-639980.155158209,-1063646.39477171,229.55)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3867.79 | 3870.84 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639983.657756804,-1063649.29891853,228.55),(-639980.155158209,-1063646.39477171,229.55)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3867.79 | 3870.84 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639937.083253457,-1063631.11058056,228.35),(-639933.580654862,-1063628.20643374,229.35)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3917.79 | 3920.84 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639937.083253457,-1063631.11058056,228.35),(-639933.580654862,-1063628.20643374,229.35)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3917.79 | 3920.84 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639890.611497705,-1063612.66415616,228.15),(-639887.10889911,-1063609.76000934,229.15)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3967.79 | 3970.84 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639890.611497705,-1063612.66415616,228.15),(-639887.10889911,-1063609.76000934,229.15)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3967.79 | 3970.84 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639843.973704373,-1063594.64484741,227.95),(-639840.471105779,-1063591.74070059,228.95)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4017.77 | 4020.79 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639843.973704373,-1063594.64484741,227.95),(-639840.471105779,-1063591.74070059,228.95)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4017.77 | 4020.79 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-639797.406509944,-1063576.4469192,227.9),(-639793.903911349,-1063573.54277238,228.9)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4067.28 | 4070.26 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-639797.406509944,-1063576.4469192,227.9),(-639793.903911349,-1063573.54277238,228.9)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4067.28 | 4070.26 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640045.54881023,-1063673.07107518,228.82),(-640044.24881023,-1063671.77107518,230.42)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3802.16 | 3802.3 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-640029.130960854,-1063666.68518308,228.75),(-640027.830960854,-1063665.38518308,230.35)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3819.78 | 3819.92 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639982.556457506,-1063648.49684512,228.55),(-639981.256457506,-1063647.19684512,230.15)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3869.78 | 3869.92 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639935.981954159,-1063630.30850715,228.35),(-639934.681954159,-1063629.00850715,229.95)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3919.78 | 3919.92 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639889.510198407,-1063611.86208275,228.15),(-639888.210198407,-1063610.56208275,229.75)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3969.78 | 3969.92 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639842.872405076,-1063593.842774,227.95),(-639841.572405076,-1063592.542774,229.55)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4019.74 | 4019.88 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-639796.305210647,-1063575.64484579,227.9),(-639795.005210647,-1063574.34484579,229.5)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 4069.23 | 4069.37 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
C3D-POVRCH | 859.489 | 1 | no | ((-640045.007940257,-1063672.7005222,228.2),(-639748.103775332,-1063558.69546069,229.9204)) | 256 | C3D-POVRCH | ByLayer
trubní vedení-potrubí | 199.544 | 1 | no | ((-640044.935186905,-1063672.51422418,228.3),(-639748.106157263,-1063558.89587636,229.4704)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3801.7 | 4118.43 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 316.73; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 445.315 | 1 | no | ((-640045.007940257,-1063672.7005222,228.2),(-639748.103775332,-1063558.69546069,229.2704)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3801.7 | 4118.5 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 19.0797 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 700.191 | 1 | no | ((-640045.007940257,-1063672.7005222,228.3),(-639748.103775332,-1063558.69546069,229.7704)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3801.7 | 4118.5 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 95.3985 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
zemní práce-výkop rýhy | 726.37 | 1 | no | ((-640005.460434484,-1063691.14422128,228.2),(-639753.64244369,-1063596.5164048,230.199972732663)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3831.76 | 4101.34 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 120.911 | objemová metoda | trvalý stav
trubní vedení-potrubí | 168.616 | 1 | no | ((-640005.384963693,-1063690.95900745,228.3),(-639753.754192349,-1063596.68227293,229.749972732663)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3831.77 | 4101.28 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 269.51; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 376.292 | 1 | no | ((-640005.460434484,-1063691.14422128,228.2),(-639753.64244369,-1063596.5164048,229.549972732663)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3831.76 | 4101.34 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 16.1215 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 591.725 | 1 | no | ((-640005.460434484,-1063691.14422128,228.3),(-639753.64244369,-1063596.5164048,230.049972732663)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3831.76 | 4101.34 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 80.6073 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640007.102231871,-1063692.31998337,229.1),(-640003.599633276,-1063689.41583655,230.1)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3830.24 | 3833.29 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640007.102231871,-1063692.31998337,229.1),(-640003.599633276,-1063689.41583655,230.1)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 3830.24 | 3833.29 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
