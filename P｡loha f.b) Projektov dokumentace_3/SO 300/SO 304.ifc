Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 3

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 304.ifc
Time: 2025-03-14T09:45:42
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 304
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (248)
In: UnknownName
Properties - IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Označení stavebního objektu | Označení podobjektu = Označení části objektu = Stavební postup / etapa výstavby | Fáze projektu | Název stavebního objektu | Staničení od | Staničení do | Označení elementu | Skupina elementů | Klasifikační systém | Označení položky | Označení šablony vlastností | Klasifikace zemin / hornin | Třída těžitelnosti | Další specifikace | Datum zahájení prací | Datum dokončení | Doba trvání | Datum uvedení do provozu | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu | Fáze
zemní práce-výkop rýhy | 22 | 2 | yes | ((-642177.737339508,-1063080.6479167,229.25),(-642174.172849014,-1063077.56630752,230.25)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1485.52 | 1488.52 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-642177.737339508,-1063080.6479167,229.25),(-642174.172849014,-1063077.56630752,230.25)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1485.52 | 1488.52 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-642183.818965088,-1063093.48075509,228.67),(-642180.251448844,-1063090.38855904,229.67)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1485.44 | 1488.45 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-642183.818965088,-1063093.48075509,228.67),(-642180.251448844,-1063090.38855904,229.67)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1485.44 | 1488.45 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-642081.655156924,-1063141.90492511,228.89),(-642078.08764068,-1063138.81272906,229.89)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1598.5 | 1601.51 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-642081.655156924,-1063141.90492511,228.89),(-642078.08764068,-1063138.81272906,229.89)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1598.5 | 1601.51 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641991.23043122,-1063184.59858826,229.65),(-641987.662914976,-1063181.50639221,230.65)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1698.5 | 1701.51 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641991.23043122,-1063184.59858826,229.65),(-641987.662914976,-1063181.50639221,230.65)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1698.5 | 1701.51 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-642126.571914341,-1063104.55678311,229.38),(-642123.007423847,-1063101.47517393,230.38)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1541.99 | 1545 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-642126.571914341,-1063104.55678311,229.38),(-642123.007423847,-1063101.47517393,230.38)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1541.99 | 1545 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-642075.297643657,-1063128.28095452,229.51),(-642071.733153163,-1063125.19934534,230.51)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1598.49 | 1601.49 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-642075.297643657,-1063128.28095452,229.51),(-642071.733153163,-1063125.19934534,230.51)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1598.49 | 1601.49 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-642029.944188184,-1063149.34050508,230.16),(-642026.379697689,-1063146.2588959,231.16)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1648.5 | 1651.5 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-642029.944188184,-1063149.34050508,230.16),(-642026.379697689,-1063146.2588959,231.16)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1648.5 | 1651.5 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641984.590740354,-1063170.40007198,230.11),(-641981.02624986,-1063167.3184628,231.11)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1698.5 | 1701.5 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641984.590740354,-1063170.40007198,230.11),(-641981.02624986,-1063167.3184628,231.11)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1698.5 | 1701.5 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641939.261549485,-1063191.5041121,230.84),(-641935.697058991,-1063188.42250292,231.84)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1748.5 | 1751.5 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641939.261549485,-1063191.5041121,230.84),(-641935.697058991,-1063188.42250292,231.84)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1748.5 | 1751.5 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641893.932358616,-1063212.60815221,230.86),(-641890.367868121,-1063209.52654304,231.86)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1798.5 | 1801.5 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641893.932358616,-1063212.60815221,230.86),(-641890.367868121,-1063209.52654304,231.86)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1798.5 | 1801.5 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
objekty na TV-šachta | 7.77544 | 2 | yes | ((-642176.605094261,-1063079.75711211,229.25),(-642175.305094261,-1063078.45711211,230.85)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1487.47 | 1487.61 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-642125.435011799,-1063103.65600675,229.38),(-642124.135011799,-1063102.35600675,230.98)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1543.95 | 1544.08 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-642074.16539841,-1063127.39014993,229.51),(-642072.86539841,-1063126.09014993,231.11)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1600.44 | 1600.58 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-642028.811942936,-1063148.44970049,230.16),(-642027.511942936,-1063147.14970049,231.76)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1650.45 | 1650.58 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641983.458495107,-1063169.50926739,230.11),(-641982.158495107,-1063168.20926739,231.71)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1700.45 | 1700.59 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641938.129304238,-1063190.61330751,230.84),(-641936.829304238,-1063189.31330751,232.44)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1750.45 | 1750.59 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641892.800113368,-1063211.71734762,230.86),(-641891.500113368,-1063210.41734762,232.46)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1800.46 | 1800.59 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 13.1987 | 2 | yes | ((-642183.040319987,-1063092.93223355,228.67),(-642181.040319987,-1063090.93223355,230.52)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1487.22 | 1487.85 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: vsakovací DN1500; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 13.1987 | 2 | yes | ((-642080.876640061,-1063141.35667412,228.89),(-642078.876640061,-1063139.35667412,230.74)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1600.28 | 1600.9 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: vsakovací DN1500; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 13.1987 | 2 | yes | ((-641990.451786119,-1063184.05006672,229.65),(-641988.451786119,-1063182.05006672,231.5)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1700.27 | 1700.9 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: vsakovací DN1500; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-výkop rýhy | 964.995 | 1 | no | ((-642182.306296364,-1063211.33740509,229.316088971691),(-641892.02759676,-1063078.83529692,231.959363519307)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1486.65 | 1800 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 160.658 | objemová metoda | trvalý stav
trubní vedení-potrubí | 196.399 | 1 | no | ((-642175.9974112,-1063211.15609254,229.700383919314),(-641892.112010961,-1063079.01650705,231.509363519307)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1487.02 | 1800 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 312.98; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 438.298 | 1 | no | ((-642176.082045065,-1063211.33740509,229.600383919314),(-641892.02759676,-1063078.83529692,231.309363519307)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1487.02 | 1800 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 18.7788 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 689.162 | 1 | no | ((-642176.082045065,-1063211.33740509,229.700383919314),(-641892.02759676,-1063078.83529692,231.809363519307)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1487.02 | 1800 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 93.894 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
trubní vedení-potrubí | 8.96833 | 1 | no | ((-642182.125570098,-1063091.97748818,229.416088971691),(-642175.864731134,-1063079.06428099,229.9)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1486.85 | 1487.12 | potrubí | trubní vedení | OTSKP | 87444 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 14.2; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 250 SN16; podrobná specifikace: nerelevantni
trubní vedení-podsyp | 19.9972 | 1 | no | ((-642182.306296364,-1063092.0631504,229.316088971691),(-642175.684004869,-1063078.97861877,229.7)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1486.65 | 1487.32 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 0.851733 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 31.8336 | 1 | no | ((-642182.306296364,-1063092.0631504,229.416088971691),(-642175.684004869,-1063078.97861877,230.2)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1486.65 | 1487.32 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 4.25867 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
trubní vedení-potrubí | 9.36457 | 1 | no | ((-642079.961971907,-1063140.40121238,229.663457266412),(-642073.496301052,-1063126.88704374,230.16)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1599.9 | 1600.11 | potrubí | trubní vedení | OTSKP | 87444 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 14.8; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 250 SN16; podrobná specifikace: nerelevantni
trubní vedení-podsyp | 20.8815 | 1 | no | ((-642080.143118117,-1063140.48598295,229.563457266412),(-642073.315154842,-1063126.80227317,229.96)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1599.7 | 1600.31 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 0.889628 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 33.2233 | 1 | no | ((-642080.143118117,-1063140.48598295,229.663457266412),(-642073.315154842,-1063126.80227317,230.46)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1599.7 | 1600.31 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 4.44814 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
trubní vedení-potrubí | 9.89265 | 1 | no | ((-641989.537255491,-1063183.09485567,230.396622561918),(-641982.717905083,-1063168.81688562,230.91)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1699.9 | 1700.1 | potrubí | trubní vedení | OTSKP | 87444 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 15.7; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 250 SN16; podrobná specifikace: nerelevantni
trubní vedení-podsyp | 22.0602 | 1 | no | ((-641989.718420278,-1063183.17958654,230.296622561918),(-641982.536740297,-1063168.73215476,230.71)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1699.7 | 1700.3 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 0.940132 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 35.0753 | 1 | no | ((-641989.718420278,-1063183.17958654,230.396622561918),(-641982.536740297,-1063168.73215476,231.21)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1699.7 | 1700.3 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P100 | 4.70066 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: fr. 16/32 mm; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641843.12362406,-1063236.36101334,231.19),(-641839.559133565,-1063233.27940416,232.19)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1854.59 | 1857.59 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641843.12362406,-1063236.36101334,230.74),(-641839.559133565,-1063233.27940416,231.74)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1854.59 | 1857.59 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641797.845096249,-1063257.56854975,230.63),(-641794.280605754,-1063254.48694057,231.63)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1904.59 | 1907.59 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641797.845096249,-1063257.56854975,230.63),(-641794.280605754,-1063254.48694057,231.63)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1904.59 | 1907.59 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641752.743561536,-1063279.15170125,230.45),(-641749.179071041,-1063276.07009207,231.45)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1954.59 | 1957.59 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641752.743561536,-1063279.15170125,230.45),(-641749.179071041,-1063276.07009207,231.45)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1954.59 | 1957.59 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641707.545076431,-1063300.53133409,230.28),(-641703.980585936,-1063297.44972491,231.28)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2004.58 | 2007.59 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641707.545076431,-1063300.53133409,230.28),(-641703.980585936,-1063297.44972491,231.28)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2004.58 | 2007.59 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641662.300556279,-1063321.8135061,230.2),(-641658.736065785,-1063318.73189692,231.2)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2054.58 | 2057.59 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641662.300556279,-1063321.8135061,230.2),(-641658.736065785,-1063318.73189692,231.2)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2054.58 | 2057.59 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641616.431492771,-1063341.63279068,229.92),(-641612.867002276,-1063338.5511815,230.92)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2104.53 | 2107.53 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641616.431492771,-1063341.63279068,229.92),(-641612.867002276,-1063338.5511815,230.92)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2104.53 | 2107.53 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 961.022 | 1 | no | ((-641892.281169403,-1063359.25832709,230.100047239801),(-641568.960066704,-1063210.79362133,231.959999999986)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1800 | 2155.45 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 160.02 | objemová metoda | trvalý stav
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641841.982662546,-1063235.4515463,230.74),(-641840.682662546,-1063234.1515463,232.34)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1856.54 | 1856.68 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641796.712851001,-1063256.67774516,230.63),(-641795.412851001,-1063255.37774516,232.23)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1906.54 | 1906.68 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641751.611316288,-1063278.26089666,230.45),(-641750.311316288,-1063276.96089666,232.05)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1956.54 | 1956.67 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641706.412831183,-1063299.6405295,230.28),(-641705.112831183,-1063298.3405295,231.88)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2006.54 | 2006.67 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641661.168311032,-1063320.92270151,230.2),(-641659.868311032,-1063319.62270151,231.8)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2056.54 | 2056.67 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641615.299247523,-1063340.74198609,229.92),(-641613.999247523,-1063339.44198609,231.52)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2106.48 | 2106.62 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trubní vedení-potrubí | 223.134 | 1 | no | ((-641892.196535175,-1063359.19139854,230.200047239801),(-641569.148535718,-1063210.97483128,231.509999999986)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1800 | 2155.31 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 355.31; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 497.962 | 1 | no | ((-641892.281169403,-1063359.25832709,230.100047239801),(-641568.960066704,-1063210.79362133,231.309999999986)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1800 | 2155.45 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 21.3362 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 782.922 | 1 | no | ((-641892.281169403,-1063359.25832709,230.200047239801),(-641568.960066704,-1063210.79362133,231.809999999986)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 1800 | 2155.45 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 106.68 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
propustky-čelo | 0.375 | 2 | yes | ((-641569.360562993,-1063359.43535117,230.200047239801),(-641569.041314714,-1063359.11610289,230.450047239801)) | 9 | propustky-čelo | Barva_9 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2155.15 | 2155.5 | čelo | propustky | OTSKP | 89516 | I1+S1;4+E1+Z1+M3;4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 191;191;191 | P50 | 0.015625 | objemová metoda | trvalý stav | CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu; CZ_S1 - Reference: D.2; Materiál: beton; specifikace: drenážní výusť; podrobná specifikace: nerelevantni; CZ_S4 - Specifikace: nerelevantni; Beton: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.2; Návrhová životnost: 25
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641522.780189345,-1063383.85707924,229.9),(-641519.21569885,-1063380.77547006,230.9)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2207.25 | 2210.25 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641522.780189345,-1063383.85707924,229.9),(-641519.21569885,-1063380.77547006,230.9)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2207.25 | 2210.25 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641477.352774468,-1063404.70088372,230.05),(-641473.788283973,-1063401.61927454,231.05)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2257.23 | 2260.23 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641477.352774468,-1063404.70088372,230.05),(-641473.788283973,-1063401.61927454,231.05)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2257.23 | 2260.23 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641431.761529181,-1063425.22339655,230.85),(-641428.197038687,-1063422.14178737,231.85)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2307.22 | 2310.22 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641431.761529181,-1063425.22339655,230.85),(-641428.197038687,-1063422.14178737,231.85)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2307.22 | 2310.22 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641386.491438728,-1063446.45080741,231.3),(-641382.926948233,-1063443.36919823,232.3)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2357.22 | 2360.22 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641386.491438728,-1063446.45080741,231.3),(-641382.926948233,-1063443.36919823,232.3)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2357.22 | 2360.22 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641341.040792775,-1063467.26173709,231.65),(-641337.476302281,-1063464.18012791,232.65)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2407.21 | 2410.21 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641341.040792775,-1063467.26173709,231.65),(-641337.476302281,-1063464.18012791,232.65)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2407.21 | 2410.21 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641288.999363181,-1063491.29404828,232.75),(-641285.434872687,-1063488.2124391,233.75)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2464.53 | 2467.53 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641288.999363181,-1063491.29404828,232.75),(-641285.434872687,-1063488.2124391,233.75)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2464.53 | 2467.53 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 838.958 | 1 | no | ((-641566.72934038,-1063490.33167748,230.1000027),(-641286.402560708,-1063359.71638218,233.849173664033)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2157.91 | 2466.8 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 140.453 | objemová metoda | trvalý stav
trubní vedení-potrubí | 193.907 | 1 | no | ((-641566.656284955,-1063490.14842215,230.2000027),(-641286.482669908,-1063359.93556496,233.399173664033)) | 4 | trubní vedení-potrubí | Barva_4 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2158.06 | 2466.79 | potrubí | trubní vedení | OTSKP | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;255;255 | P10 |  |  | trvalý stav | CZ_M1 - Délka: 308.73; Způsob stanovení délky: Délka 3D křivky; CZ_S1 - Reference: D.2; Materiál: plast; specifikace: DN 200 děrované; podrobná specifikace: plášť z rostlinných vláken
trubní vedení-podsyp | 432.743 | 1 | no | ((-641566.72934038,-1063490.33167748,230.1000027),(-641286.402560708,-1063359.71638218,233.199173664033)) | 2 | trubní vedení-podsyp | Barva_2 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2157.91 | 2466.8 | podsyp | trubní vedení | OTSKP | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;255;0 | P100 | 18.5399 | objemová metoda | trvalý stav | CZ_S1 - Reference: D.2; Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni
trubní vedení-obsyp | 680.422 | 1 | no | ((-641566.72934038,-1063490.33167748,230.2000027),(-641286.402560708,-1063359.71638218,233.699173664033)) | 40 | trubní vedení-obsyp | Barva_40 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2157.91 | 2466.8 | obsyp | trubní vedení | OTSKP | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 255;165;0 | P10 | 92.6997 | objemová metoda | trvalý stav | CZ_S2 - Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M6 - Tloušťka: 0.5
propustky-čelo | 0.375 | 2 | yes | ((-641566.898141589,-1063360.58259409,230.2000027),(-641566.574097602,-1063360.25855011,230.4500027)) | 9 | propustky-čelo | Barva_9 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2157.87 | 2158.22 | čelo | propustky | OTSKP | 89516 | I1+S1;4+E1+Z1+M3;4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 191;191;191 | P50 | 0.015625 | objemová metoda | trvalý stav | CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu; CZ_S1 - Reference: D.2; Materiál: beton; specifikace: drenážní výusť; podrobná specifikace: nerelevantni; CZ_S4 - Specifikace: nerelevantni; Beton: nerelevantni; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.2; Návrhová životnost: 25
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641521.647944098,-1063382.96627465,229.9),(-641520.347944097,-1063381.66627465,231.5)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2209.2 | 2209.34 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641476.22052922,-1063403.81007913,230.05),(-641474.92052922,-1063402.51007913,231.65)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2259.18 | 2259.32 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641430.629283934,-1063424.33259196,230.85),(-641429.329283934,-1063423.03259196,232.45)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2309.18 | 2309.31 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641385.35919348,-1063445.56000282,231.3),(-641384.05919348,-1063444.26000282,232.9)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2359.18 | 2359.31 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641339.908547528,-1063466.3709325,231.65),(-641338.608547528,-1063465.0709325,233.25)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2409.16 | 2409.3 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641287.867117934,-1063490.40324369,232.75),(-641286.567117934,-1063489.10324369,234.35)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2466.48 | 2466.62 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641234.083907036,-1063517.71189436,233.95),(-641230.519416542,-1063514.63028519,234.95)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2525.47 | 2528.47 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641234.083907036,-1063517.71189436,233.95),(-641230.519416542,-1063514.63028519,234.95)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2525.47 | 2528.47 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641189.632585217,-1063540.58284679,236.45),(-641186.068094722,-1063537.50123761,237.45)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2575.42 | 2578.42 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641189.632585217,-1063540.58284679,236.45),(-641186.068094722,-1063537.50123761,237.45)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2575.42 | 2578.42 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641142.674324367,-1063557.68781616,238.85),(-641139.109833873,-1063554.60620698,239.85)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2625.2 | 2628.2 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641142.674324367,-1063557.68781616,238.85),(-641139.109833873,-1063554.60620698,239.85)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2625.2 | 2628.2 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641096.799255779,-1063577.50798253,239.95),(-641093.234765285,-1063574.42637336,240.95)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2675.15 | 2678.16 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641096.799255779,-1063577.50798253,239.95),(-641093.234765285,-1063574.42637336,240.95)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2675.15 | 2678.16 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641051.838795838,-1063599.38297889,240.05),(-641048.274305344,-1063596.30136972,241.05)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2725.15 | 2728.15 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641051.838795838,-1063599.38297889,240.05),(-641048.274305344,-1063596.30136972,241.05)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2725.15 | 2728.15 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-641006.767200945,-1063621.02572497,240.15),(-641003.202710451,-1063617.94411579,241.15)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2775.14 | 2778.15 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-641006.767200945,-1063621.02572497,240.15),(-641003.202710451,-1063617.94411579,241.15)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2775.14 | 2778.15 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 22 | 2 | yes | ((-640978.319509163,-1063633.06212388,240.25),(-640974.755018669,-1063629.9805147,241.25)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2806.01 | 2809.01 | výkop rýhy | zemní práce | OTSKP | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-zásyp rýhy | 22 | 2 | yes | ((-640978.319509163,-1063633.06212388,240.25),(-640974.755018669,-1063629.9805147,241.25)) | 96 | zemní práce-zásyp rýhy | Barva_96 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2806.01 | 2809.01 | zásyp rýhy | zemní práce | OTSKP | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;128;0 | P100 | 6 | objemová metoda | trvalý stav
zemní práce-výkop rýhy | 873.168 | 1 | no | ((-641270.132184182,-1063631.80412027,233.300017999999),(-640976.437145953,-1063497.20507571,241.350000000005)) | 36 | zemní práce-výkop rýhy | Barva_36 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2484.89 | 2807.54 | výkop rýhy | zemní práce | OTSKP | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 125;75;0 | P100 | 145.35 | objemová metoda | trvalý stav
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641232.951661789,-1063516.82108977,233.95),(-641231.651661788,-1063515.52108977,235.55)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2527.42 | 2527.56 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641188.500339969,-1063539.6920422,236.45),(-641187.200339969,-1063538.3920422,238.05)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2577.37 | 2577.51 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641141.54207912,-1063556.79701157,238.85),(-641140.24207912,-1063555.49701157,240.45)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2627.16 | 2627.29 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
objekty na TV-šachta | 7.77544 | 2 | yes | ((-641095.667010532,-1063576.61717794,239.95),(-641094.367010532,-1063575.31717794,241.55)) | 5 | objekty na TV-šachta | Barva_5 | SO 304 | nerelevantni | PDPS | Úprava meliorací | 2677.11 | 2677.24 | šachta | objekty na TV | OTSKP | 89413 | I1+S2+E1+Z1+M4+F1 |  |  |  | 01.05.2025 | 30.06.2027 | 790 | 01.07.2027 | 0;0;255 | P10 |  |  | trvalý stav | CZ_S2 - Typ stavebního výrobku: šachta; Stavební výrobek: drenážní DN800; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Reference: D.2; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
