Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 303.ifc
Time: 2025-03-14T09:45:07
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, SO 303
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (14)
In: UnknownName
Properties - IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 303; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka tlakové kanalizace; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Klasifikace zemin / hornin | Třída těžitelnosti | Další specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
zemní práce-výkop rýhy | 323.722 | 1 | no | ((-641283.257019439,-1063525.98247884,232.270000005583),(-641264.373711699,-1063470.41819248,234.550001739524)) | 36 | zemní práce-výkop rýhy | Barva_36 | 0 | 64.2 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 87.3103 | objemová metoda
zemní práce-zásyp rýhy | 260.023 | 1 | no | ((-641283.257019439,-1063525.98247884,232.760000005583),(-641264.373711699,-1063470.41819248,234.550001739524)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 0 | 64.2 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 62.1444 | objemová metoda
trubní vedení-potrubí | 18.136 | 1 | no | ((-641282.969998163,-1063525.83206637,232.370000005583),(-641264.784079773,-1063470.62710344,233.040001739524)) | 4 | trubní vedení-potrubí | Barva_4 | 0 | 64.2 | potrubí | trubní vedení | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 0;255;255 | P10 | CZ_S1 - Materiál: litina; specifikace: LT DN250; podrobná specifikace: nerelevantni; Reference: D.4; CZ_M1 - Délka: 64.2; Způsob stanovení délky: Délka 3D křivky
trubní vedení-podsyp | 115.726 | 1 | no | ((-641283.257019439,-1063525.98247884,232.270000005583),(-641264.373711699,-1063470.41819248,232.950001739524)) | 2 | trubní vedení-podsyp | Barva_2 | 0 | 64.2 | podsyp | trubní vedení | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 255;255;0 | P100 | 5.13589 | objemová metoda | CZ_S1 - Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.4
trubní vedení-obsyp | 153.425 | 1 | no | ((-641283.257019439,-1063525.98247884,232.370000005583),(-641264.373711699,-1063470.41819248,233.340001739524)) | 40 | trubní vedení-obsyp | Barva_40 | 0 | 64.2 | obsyp | trubní vedení | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 255;165;0 | P100 | 20.03 | objemová metoda | CZ_M6 - Tloušťka: 0.2; CZ_S2 - Reference: D.4; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641281.213100111,-1063528.26015352,232.850001739524),(-641277.648294104,-1063525.17745434,234.850001739524)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 0.1 | 0 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 12 | objemová metoda
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641281.213100111,-1063528.26015352,232.850001739524),(-641277.648294104,-1063525.17745434,234.850001739524)) | 36 | zemní práce-výkop rýhy | Barva_36 | 0.1 | 0 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 12 | objemová metoda
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641285.323344265,-1063471.53630745,232.270000005583),(-641281.720849228,-1063468.15384149,234.270000005583)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 64.2 | 64.2 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 12 | objemová metoda
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641285.323344265,-1063471.53630745,232.270000005583),(-641281.720849228,-1063468.15384149,234.270000005583)) | 36 | zemní práce-výkop rýhy | Barva_36 | 64.2 | 64.2 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 12 | objemová metoda
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641266.139156384,-1063495.47318922,232.270072297874),(-641262.756690423,-1063491.87069419,234.270072297874)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 36.21 | 36.21 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 12 | objemová metoda
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641266.139156384,-1063495.47318922,232.270072297874),(-641262.756690423,-1063491.87069419,234.270072297874)) | 36 | zemní práce-výkop rýhy | Barva_36 | 36.21 | 36.21 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 12 | objemová metoda
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-641265.644803021,-1063499.03799523,232.270072297874),(-641262.562103837,-1063495.47318922,234.270072297874)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 30.68 | 30.68 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 12 | objemová metoda
zemní práce-výkop rýhy | 32 | 2 | yes | ((-641265.644803021,-1063499.03799523,232.270072297874),(-641262.562103837,-1063495.47318922,234.270072297874)) | 36 | zemní práce-výkop rýhy | Barva_36 | 30.68 | 30.68 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 12 | objemová metoda
trubní vedení-chránička | 26.1162 | 1 | no | ((-641275.750373245,-1063518.69951866,232.413288685071),(-641266.290245807,-1063498.77767315,232.993020762001)) | 216 | trubní vedení-chránička | Barva_216 | 7.9 | 29.8 | chránička | trubní vedení | 86657 | I1+S1+E1+Z1+M1+F1 |  |  |  | 127;0;127 | P10 | CZ_S1 - Materiál: ocel; specifikace: DN 200; podrobná specifikace: nerelevantni; Reference: D.4; CZ_M1 - Délka: 21.9; Způsob stanovení délky: Délka 3D křivky
