Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 302.ifc
Time: 2025-03-14T09:44:39
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, Unknown
Summary - Title: CAD Studio Silniční šablona; Author: Martin Folber, Ondřej Vojtěchovský, Jakub Kareš; HyperlinkBase: www.cadstudio.cz
Custom_Properties - Investor: Správa a údržba silnic Pardubického kraje, Doubravice 98, 533 53 Pardubice; Stupeň PD: DÚSP; Příloha č.: 2.; Část: D; Datum PD: 02.2022; Místo: Pardubický kraj/obec

# IfcBuiltElement (10)
In: UnknownName
Properties - IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - Linetype: ByLayer; LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_I1 - Označení stavebního objektu: SO 302; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka vodovodu; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory = IsModified = IsModifiedGraphics | Bounds | ColorIndex | Layer | PlotStyleName | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Klasifikace zemin / hornin | Třída těžitelnosti | Další specifikace | Textura / barva | Skupina přesnosti | Objem | Způsob stanovení objemu
zemní práce-výkop rýhy | 2171.71 | 1 | no | ((-639385.673083077,-1063494.5720471,227.650002035334),(-639048.379215319,-1063457.0025478,230.099999994412)) | 36 | zemní práce-výkop rýhy | Barva_36 | 0 | 344 | výkop rýhy | zemní práce | 132736 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 775.718 | objemová metoda
zemní práce-zásyp rýhy | 1688.57 | 1 | no | ((-639385.671655565,-1063494.57210383,228.349999119593),(-639048.377787807,-1063457.00260453,230.099997078672)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 0 | 344 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 510.839 | objemová metoda
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-639048.401058076,-1063495.522481,227.650002035334),(-639046.401058076,-1063492.522481,229.650002035334)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 343.94 | 343.94 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 12 | objemová metoda
zemní práce-výkop rýhy | 32 | 2 | yes | ((-639048.401058076,-1063495.522481,227.650002035334),(-639046.401058076,-1063492.522481,229.650002035334)) | 36 | zemní práce-výkop rýhy | Barva_36 | 343.94 | 343.94 | výkop rýhy | zemní práce | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 12 | objemová metoda
zemní práce-zásyp rýhy | 32 | 2 | yes | ((-639387.883598222,-1063458.80077874,227.749999994412),(-639384.688773426,-1063455.20891917,229.749999994412)) | 96 | zemní práce-zásyp rýhy | Barva_96 | 0 | 0.1 | zásyp rýhy | zemní práce | 17481 | I1+S3+E1+Z1+M3+F1 | fr. 0/63 mm | 1 | nerelevantni | 0;128;0 | P100 | 12 | objemová metoda
zemní práce-výkop rýhy | 32 | 2 | yes | ((-639387.883598222,-1063458.80077874,227.749999994412),(-639384.688773426,-1063455.20891917,229.749999994412)) | 36 | zemní práce-výkop rýhy | Barva_36 | 0 | 0.1 | výkop rýhy | zemní práce | 131836 | I1+S3+E1+Z1+M3+F1 | nerelevantni | 1 | nerelevantni | 125;75;0 | P100 | 12 | objemová metoda
trubní vedení-potrubí | 269.84 | 1 | no | ((-639385.469018881,-1063494.14738239,227.800002035334),(-639048.396093813,-1063457.37535177,228.449999463949)) | 4 | trubní vedení-potrubí | Barva_4 | 0 | 344 | potrubí | trubní vedení | 85145 | I1+S1+E1+Z1+M1+F1 |  |  |  | 0;255;255 | P10 | CZ_S1 - Materiál: litina; specifikace: LT DN300; podrobná specifikace: nerelevantni; Reference: D.4; CZ_M1 - Délka: 344; Způsob stanovení délky: Délka 3D křivky
trubní vedení-podsyp | 860.329 | 1 | no | ((-639385.673083077,-1063494.5720471,227.650002035334),(-639048.379215319,-1063457.0025478,228.199999994412)) | 2 | trubní vedení-podsyp | Barva_2 | 0 | 344 | podsyp | trubní vedení | 45157 | I1+S1+E1+Z1+M3+F1 |  |  |  | 255;255;0 | P100 | 56.76 | objemová metoda | CZ_S1 - Materiál: ŠP fr. 0/4; specifikace: nerelevantni; podrobná specifikace: nerelevantni; Reference: D.4
trubní vedení-obsyp | 1136.41 | 1 | no | ((-639385.673083077,-1063494.5720471,227.800002035334),(-639048.379215319,-1063457.0025478,228.749999994412)) | 40 | trubní vedení-obsyp | Barva_40 | 0 | 344 | obsyp | trubní vedení | 17581 | I1+S2+E1+Z1+M3;2&6+F1 |  |  |  | 255;165;0 | P10 | 208.119 | objemová metoda | CZ_M6 - Tloušťka: 0.55; CZ_S2 - Reference: D.4; Typ stavebního výrobku: obsyp; Stavební výrobek: ŠP fr. 0/4; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni
objekty na TV-odlučovač | 0.462442 | 2 | yes | ((-639244.315864899,-1063488.2616328,228.2),(-639244.235864899,-1063488.1816328,230)) | 4 | objekty na TV-odlučovač | Barva_4 | 148.05 | 148.05 | odlučovač | objekty na TV | 891426 | I1+S2+E1+Z1+M4+F1 |  |  |  | 0;255;255 | P10 | CZ_S2 - Reference: D.4; Typ stavebního výrobku: hydrant; Stavební výrobek: vzdušník; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
